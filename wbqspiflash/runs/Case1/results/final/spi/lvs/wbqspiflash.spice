* NGSPICE file created from wbqspiflash.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_2 abstract view
.subckt sky130_fd_sc_hd__a31o_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VGND VPWR VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_1 abstract view
.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_1 abstract view
.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_2 abstract view
.subckt sky130_fd_sc_hd__or4_2 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_8 abstract view
.subckt sky130_fd_sc_hd__nor2_8 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_4 abstract view
.subckt sky130_fd_sc_hd__dfxtp_4 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_4 abstract view
.subckt sky130_fd_sc_hd__nand4_4 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_1 abstract view
.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_8 abstract view
.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_12 abstract view
.subckt sky130_fd_sc_hd__buf_12 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_4 abstract view
.subckt sky130_fd_sc_hd__o2111ai_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_4 abstract view
.subckt sky130_fd_sc_hd__nor2b_4 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_1 abstract view
.subckt sky130_fd_sc_hd__o2111ai_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_2 abstract view
.subckt sky130_fd_sc_hd__nand4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_2 abstract view
.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_1 abstract view
.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_2 abstract view
.subckt sky130_fd_sc_hd__and4b_2 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_2 abstract view
.subckt sky130_fd_sc_hd__nand3b_2 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_1 abstract view
.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111oi_1 abstract view
.subckt sky130_fd_sc_hd__a2111oi_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_1 abstract view
.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_1 abstract view
.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_1 abstract view
.subckt sky130_fd_sc_hd__o221ai_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_1 abstract view
.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311oi_2 abstract view
.subckt sky130_fd_sc_hd__a311oi_2 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_2 abstract view
.subckt sky130_fd_sc_hd__clkinv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_4 abstract view
.subckt sky130_fd_sc_hd__or4_4 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311oi_1 abstract view
.subckt sky130_fd_sc_hd__a311oi_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_4 abstract view
.subckt sky130_fd_sc_hd__nor4_4 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_1 abstract view
.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32ai_1 abstract view
.subckt sky130_fd_sc_hd__o32ai_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4b_4 abstract view
.subckt sky130_fd_sc_hd__nor4b_4 A B C D_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_1 abstract view
.subckt sky130_fd_sc_hd__or4bb_1 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4b_1 abstract view
.subckt sky130_fd_sc_hd__nor4b_1 A B C D_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_2 abstract view
.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_1 abstract view
.subckt sky130_fd_sc_hd__nor4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_2 abstract view
.subckt sky130_fd_sc_hd__a211oi_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_1 abstract view
.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_1 abstract view
.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_2 abstract view
.subckt sky130_fd_sc_hd__nor4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32oi_1 abstract view
.subckt sky130_fd_sc_hd__a32oi_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_2 abstract view
.subckt sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_2 abstract view
.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_1 abstract view
.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_2 abstract view
.subckt sky130_fd_sc_hd__and4_2 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_1 abstract view
.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_4 abstract view
.subckt sky130_fd_sc_hd__or4b_4 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_2 abstract view
.subckt sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_8 abstract view
.subckt sky130_fd_sc_hd__nand2_8 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_4 abstract view
.subckt sky130_fd_sc_hd__a31o_4 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_2 abstract view
.subckt sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_2 abstract view
.subckt sky130_fd_sc_hd__a311o_2 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_4 abstract view
.subckt sky130_fd_sc_hd__and3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_4 abstract view
.subckt sky130_fd_sc_hd__or3b_4 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_2 abstract view
.subckt sky130_fd_sc_hd__nor3b_2 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_2 abstract view
.subckt sky130_fd_sc_hd__or2b_2 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_2 abstract view
.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_4 abstract view
.subckt sky130_fd_sc_hd__a221oi_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_1 abstract view
.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4b_1 abstract view
.subckt sky130_fd_sc_hd__nand4b_1 A_N B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_4 abstract view
.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311oi_4 abstract view
.subckt sky130_fd_sc_hd__a311oi_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o41a_1 abstract view
.subckt sky130_fd_sc_hd__o41a_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_1 abstract view
.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_2 abstract view
.subckt sky130_fd_sc_hd__o31a_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_4 abstract view
.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_4 abstract view
.subckt sky130_fd_sc_hd__a311o_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_8 abstract view
.subckt sky130_fd_sc_hd__inv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_1 abstract view
.subckt sky130_fd_sc_hd__nor3b_1 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_1 abstract view
.subckt sky130_fd_sc_hd__a221oi_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2ai_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2ai_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_2 abstract view
.subckt sky130_fd_sc_hd__and3b_2 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_4 abstract view
.subckt sky130_fd_sc_hd__and4_4 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_6 abstract view
.subckt sky130_fd_sc_hd__inv_6 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_2 abstract view
.subckt sky130_fd_sc_hd__or4bb_2 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311ai_1 abstract view
.subckt sky130_fd_sc_hd__o311ai_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2oi_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2oi_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_2 abstract view
.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_1 abstract view
.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_4 abstract view
.subckt sky130_fd_sc_hd__a22o_4 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_2 abstract view
.subckt sky130_fd_sc_hd__or4b_2 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_4 abstract view
.subckt sky130_fd_sc_hd__nor3_4 A B C VGND VNB VPB VPWR Y
.ends

.subckt wbqspiflash VGND VPWR i_clk i_qspi_dat[0] i_qspi_dat[1] i_qspi_dat[2] i_qspi_dat[3]
+ i_wb_addr[0] i_wb_addr[10] i_wb_addr[11] i_wb_addr[12] i_wb_addr[13] i_wb_addr[14]
+ i_wb_addr[15] i_wb_addr[16] i_wb_addr[17] i_wb_addr[18] i_wb_addr[19] i_wb_addr[1]
+ i_wb_addr[2] i_wb_addr[3] i_wb_addr[4] i_wb_addr[5] i_wb_addr[6] i_wb_addr[7] i_wb_addr[8]
+ i_wb_addr[9] i_wb_ctrl_stb i_wb_cyc i_wb_data[0] i_wb_data[10] i_wb_data[11] i_wb_data[12]
+ i_wb_data[13] i_wb_data[14] i_wb_data[15] i_wb_data[16] i_wb_data[17] i_wb_data[18]
+ i_wb_data[19] i_wb_data[1] i_wb_data[20] i_wb_data[21] i_wb_data[22] i_wb_data[23]
+ i_wb_data[24] i_wb_data[25] i_wb_data[26] i_wb_data[27] i_wb_data[28] i_wb_data[29]
+ i_wb_data[2] i_wb_data[30] i_wb_data[31] i_wb_data[3] i_wb_data[4] i_wb_data[5]
+ i_wb_data[6] i_wb_data[7] i_wb_data[8] i_wb_data[9] i_wb_data_stb i_wb_we o_interrupt
+ o_qspi_cs_n o_qspi_dat[0] o_qspi_dat[1] o_qspi_dat[2] o_qspi_dat[3] o_qspi_mod[0]
+ o_qspi_mod[1] o_qspi_sck o_wb_ack o_wb_data[0] o_wb_data[10] o_wb_data[11] o_wb_data[12]
+ o_wb_data[13] o_wb_data[14] o_wb_data[15] o_wb_data[16] o_wb_data[17] o_wb_data[18]
+ o_wb_data[19] o_wb_data[1] o_wb_data[20] o_wb_data[21] o_wb_data[22] o_wb_data[23]
+ o_wb_data[24] o_wb_data[25] o_wb_data[26] o_wb_data[27] o_wb_data[28] o_wb_data[29]
+ o_wb_data[2] o_wb_data[30] o_wb_data[31] o_wb_data[3] o_wb_data[4] o_wb_data[5]
+ o_wb_data[6] o_wb_data[7] o_wb_data[8] o_wb_data[9] o_wb_stall
XTAP_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3155_ _3363_/CLK _3155_/D VGND VGND VPWR VPWR _3155_/Q sky130_fd_sc_hd__dfxtp_1
X_3086_ _2832_/A _3196_/Q _3085_/X _2816_/A VGND VGND VPWR VPWR _3086_/X sky130_fd_sc_hd__o211a_1
X_2106_ _2726_/A _2520_/A _1873_/B _1647_/X VGND VGND VPWR VPWR _2110_/C sky130_fd_sc_hd__a31o_2
X_2037_ _3288_/Q _2335_/C VGND VGND VPWR VPWR _2038_/D sky130_fd_sc_hd__nand2_1
XFILLER_35_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2939_ _3375_/Q _2906_/X _2938_/X VGND VGND VPWR VPWR _3375_/D sky130_fd_sc_hd__a21o_1
XFILLER_77_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2724_ _3286_/Q input50/X _2725_/S VGND VGND VPWR VPWR _3286_/D sky130_fd_sc_hd__mux2_1
XFILLER_8_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2655_ _2312_/X _2433_/X _2653_/X _2654_/X VGND VGND VPWR VPWR _2655_/Y sky130_fd_sc_hd__a22oi_1
X_1606_ _1606_/A VGND VGND VPWR VPWR _3122_/A sky130_fd_sc_hd__buf_4
X_2586_ _2188_/A _1650_/Y _2585_/X _1653_/A VGND VGND VPWR VPWR _2586_/X sky130_fd_sc_hd__a31o_1
XFILLER_59_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3207_ _3208_/CLK _3207_/D VGND VGND VPWR VPWR _3207_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_82_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3138_ _3343_/CLK _3138_/D VGND VGND VPWR VPWR _3138_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_82_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3069_ _3066_/X _2826_/X _2922_/A _3068_/X VGND VGND VPWR VPWR _3069_/X sky130_fd_sc_hd__a211o_1
XFILLER_42_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_272 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2440_ _1964_/B _2437_/X _2451_/C _2439_/X VGND VGND VPWR VPWR _2440_/X sky130_fd_sc_hd__a31o_1
X_2371_ _2448_/B _2594_/B _2492_/B _2109_/A VGND VGND VPWR VPWR _2371_/X sky130_fd_sc_hd__a31o_1
XFILLER_78_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2707_ _3269_/Q input31/X _2717_/S VGND VGND VPWR VPWR _3269_/D sky130_fd_sc_hd__mux2_1
X_2638_ _2616_/C _1873_/B _2641_/A _2641_/B VGND VGND VPWR VPWR _2692_/C sky130_fd_sc_hd__a211o_1
XFILLER_59_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2569_ _2335_/B _3242_/Q _2574_/S VGND VGND VPWR VPWR _3242_/D sky130_fd_sc_hd__mux2_1
XFILLER_59_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_128 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1940_ _3162_/Q _1939_/X _1942_/S VGND VGND VPWR VPWR _3162_/D sky130_fd_sc_hd__mux2_1
XFILLER_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1871_ _1871_/A _1871_/B VGND VGND VPWR VPWR _1872_/D sky130_fd_sc_hd__nor2_1
XFILLER_50_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2423_ _2492_/A _2492_/D _2552_/C _2613_/C VGND VGND VPWR VPWR _2423_/X sky130_fd_sc_hd__or4_1
X_2354_ _1872_/B _2352_/X _2353_/Y _2129_/X VGND VGND VPWR VPWR _2354_/Y sky130_fd_sc_hd__o31ai_1
X_2285_ _3187_/Q _2162_/X _2164_/X input23/X _2284_/X VGND VGND VPWR VPWR _2285_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_56_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2070_ _2552_/A _2552_/B _2070_/C _2070_/D VGND VGND VPWR VPWR _2076_/D sky130_fd_sc_hd__or4_2
XFILLER_81_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2972_ _2832_/A _3177_/Q _2971_/X _2816_/X VGND VGND VPWR VPWR _2972_/X sky130_fd_sc_hd__o211a_1
XFILLER_34_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1923_ _3153_/Q _3150_/Q _2884_/S VGND VGND VPWR VPWR _1923_/X sky130_fd_sc_hd__mux2_1
X_1854_ _2726_/A _2324_/D VGND VGND VPWR VPWR _1854_/Y sky130_fd_sc_hd__nor2_8
X_1785_ _1785_/A _2025_/B _2023_/B VGND VGND VPWR VPWR _1785_/X sky130_fd_sc_hd__and3_1
X_2406_ _2389_/A _3199_/Q _2389_/C VGND VGND VPWR VPWR _2406_/X sky130_fd_sc_hd__a21bo_1
X_3386_ _3388_/CLK _3386_/D VGND VGND VPWR VPWR _3386_/Q sky130_fd_sc_hd__dfxtp_1
X_2337_ _2436_/C _2492_/A _2337_/C VGND VGND VPWR VPWR _2341_/B sky130_fd_sc_hd__and3_1
XFILLER_57_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2268_ _2733_/A _2090_/X _2267_/X _2247_/D VGND VGND VPWR VPWR _2268_/X sky130_fd_sc_hd__a31o_1
XFILLER_44_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2199_ _2001_/X _2187_/X _2190_/X _3235_/Q VGND VGND VPWR VPWR _2199_/X sky130_fd_sc_hd__a22o_1
XFILLER_52_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_315 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1570_ _1570_/A VGND VGND VPWR VPWR _2885_/S sky130_fd_sc_hd__clkbuf_8
XANTENNA_5 _2056_/C VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_260 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3240_ _3240_/CLK _3240_/D VGND VGND VPWR VPWR _3240_/Q sky130_fd_sc_hd__dfxtp_4
X_3171_ _3194_/CLK _3171_/D VGND VGND VPWR VPWR _3171_/Q sky130_fd_sc_hd__dfxtp_2
XTAP_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2122_ _2128_/A _2128_/B _2128_/C _2128_/D VGND VGND VPWR VPWR _2247_/D sky130_fd_sc_hd__nand4_4
X_2053_ _3165_/Q _2459_/A _3200_/Q _2053_/D VGND VGND VPWR VPWR _2550_/B sky130_fd_sc_hd__or4_1
XFILLER_62_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2955_ _2952_/X _2826_/X _3100_/A _2954_/X VGND VGND VPWR VPWR _2955_/X sky130_fd_sc_hd__a211o_1
X_1906_ _3145_/Q _1905_/X _1932_/S VGND VGND VPWR VPWR _3145_/D sky130_fd_sc_hd__mux2_1
X_2886_ _3334_/Q _1630_/Y _1647_/X _2801_/C _3365_/Q VGND VGND VPWR VPWR _2886_/X
+ sky130_fd_sc_hd__a32o_1
X_1837_ _3254_/Q _3253_/Q VGND VGND VPWR VPWR _1838_/A sky130_fd_sc_hd__or2_1
X_1768_ _1809_/C _1781_/D VGND VGND VPWR VPWR _1796_/B sky130_fd_sc_hd__nor2_2
XFILLER_1_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1699_ _3236_/Q _3237_/Q _3238_/Q _3239_/Q VGND VGND VPWR VPWR _1700_/A sky130_fd_sc_hd__and4_1
XTAP_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3369_ _3404_/CLK _3369_/D VGND VGND VPWR VPWR _3369_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_212 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_32 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_178 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput75 _3314_/Q VGND VGND VPWR VPWR o_wb_data[13] sky130_fd_sc_hd__clkbuf_1
Xoutput64 _1584_/X VGND VGND VPWR VPWR o_qspi_dat[1] sky130_fd_sc_hd__clkbuf_1
Xoutput86 _3318_/Q VGND VGND VPWR VPWR o_wb_data[23] sky130_fd_sc_hd__clkbuf_1
Xoutput97 _3305_/Q VGND VGND VPWR VPWR o_wb_data[4] sky130_fd_sc_hd__clkbuf_1
XFILLER_36_407 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2740_ _2740_/A _2740_/B _2740_/C _2739_/X VGND VGND VPWR VPWR _2741_/D sky130_fd_sc_hd__or4b_1
XFILLER_8_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2671_ _2671_/A VGND VGND VPWR VPWR _2832_/A sky130_fd_sc_hd__buf_8
X_1622_ _1860_/D VGND VGND VPWR VPWR _2384_/C sky130_fd_sc_hd__buf_12
X_3223_ _3266_/CLK _3223_/D VGND VGND VPWR VPWR _3223_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3154_ _3356_/CLK _3154_/D VGND VGND VPWR VPWR _3154_/Q sky130_fd_sc_hd__dfxtp_1
X_3085_ _3167_/Q _3199_/Q VGND VGND VPWR VPWR _3085_/X sky130_fd_sc_hd__or2_1
X_2105_ _2726_/B _2120_/B _2543_/C _2740_/C _2104_/X VGND VGND VPWR VPWR _2613_/B
+ sky130_fd_sc_hd__o2111ai_4
XFILLER_39_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2036_ _2739_/A _2740_/B VGND VGND VPWR VPWR _2335_/C sky130_fd_sc_hd__nor2b_4
XFILLER_50_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2938_ _3175_/Q _2907_/X _2909_/X _2937_/X VGND VGND VPWR VPWR _2938_/X sky130_fd_sc_hd__o211a_1
X_2869_ _3350_/Q _1913_/X _3331_/D VGND VGND VPWR VPWR _3350_/D sky130_fd_sc_hd__mux2_1
XFILLER_77_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2723_ _3285_/Q input48/X _2725_/S VGND VGND VPWR VPWR _3285_/D sky130_fd_sc_hd__mux2_1
XFILLER_8_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2654_ _2384_/C _2004_/B _2851_/B _2187_/X VGND VGND VPWR VPWR _2654_/X sky130_fd_sc_hd__o22a_1
X_2585_ _2585_/A _3287_/Q VGND VGND VPWR VPWR _2585_/X sky130_fd_sc_hd__or2_1
X_1605_ _2520_/A _2448_/A _2043_/B VGND VGND VPWR VPWR _1606_/A sky130_fd_sc_hd__and3_1
XFILLER_59_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3206_ _3208_/CLK _3206_/D VGND VGND VPWR VPWR _3206_/Q sky130_fd_sc_hd__dfxtp_1
X_3137_ _3345_/CLK _3137_/D VGND VGND VPWR VPWR _3137_/Q sky130_fd_sc_hd__dfxtp_1
X_3068_ _2832_/A _3193_/Q _3067_/X _2816_/A VGND VGND VPWR VPWR _3068_/X sky130_fd_sc_hd__o211a_1
XFILLER_63_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2019_ _1749_/A _1748_/A _1730_/Y _1736_/Y _2018_/X VGND VGND VPWR VPWR _2026_/B
+ sky130_fd_sc_hd__o2111ai_1
XFILLER_35_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_284 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_74 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2370_ _2585_/A _2135_/X _2337_/C _2312_/X VGND VGND VPWR VPWR _2370_/X sky130_fd_sc_hd__o211a_1
XFILLER_68_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2706_ _3268_/Q input30/X _2717_/S VGND VGND VPWR VPWR _3268_/D sky130_fd_sc_hd__mux2_1
X_2637_ _2637_/A _2637_/B _2637_/C _2637_/D VGND VGND VPWR VPWR _2641_/B sky130_fd_sc_hd__nand4_2
X_2568_ input9/X _3241_/Q _2574_/S VGND VGND VPWR VPWR _3241_/D sky130_fd_sc_hd__mux2_1
X_2499_ _2499_/A _3125_/C VGND VGND VPWR VPWR _2499_/X sky130_fd_sc_hd__or2_2
XFILLER_55_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_21 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1870_ _2612_/B _2097_/A _2644_/D VGND VGND VPWR VPWR _1871_/B sky130_fd_sc_hd__o21ba_1
X_2422_ _3200_/Q _2129_/X _2421_/X VGND VGND VPWR VPWR _3200_/D sky130_fd_sc_hd__o21a_1
XFILLER_43_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2353_ _2130_/X _2143_/X _2644_/D _2733_/A VGND VGND VPWR VPWR _2353_/Y sky130_fd_sc_hd__a31oi_2
XFILLER_69_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2284_ _3236_/Q _2577_/D _2120_/B _2283_/X VGND VGND VPWR VPWR _2284_/X sky130_fd_sc_hd__o31a_1
XFILLER_37_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_184 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1999_ _2492_/C _1997_/X _1998_/X VGND VGND VPWR VPWR _1999_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_4_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_19_i_clk clkbuf_2_2__f_i_clk/X VGND VGND VPWR VPWR _3240_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_50_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_118 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_313 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2971_ _3055_/A _3180_/Q VGND VGND VPWR VPWR _2971_/X sky130_fd_sc_hd__or2_1
X_1922_ _3153_/Q _1921_/X _1932_/S VGND VGND VPWR VPWR _3153_/D sky130_fd_sc_hd__mux2_1
X_1853_ _3200_/Q _2459_/A _2851_/A VGND VGND VPWR VPWR _1853_/X sky130_fd_sc_hd__or3_1
X_1784_ _1743_/B _1743_/C input23/X VGND VGND VPWR VPWR _2023_/B sky130_fd_sc_hd__a21bo_1
X_2405_ _3198_/Q _2247_/D _2396_/X _2404_/X VGND VGND VPWR VPWR _3198_/D sky130_fd_sc_hd__a22o_1
X_3385_ _3389_/CLK _3385_/D VGND VGND VPWR VPWR _3385_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_69_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2336_ _3193_/Q _2162_/X _2368_/C _2494_/B _2494_/A VGND VGND VPWR VPWR _2336_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_57_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2267_ _2389_/C _2335_/B _2266_/X VGND VGND VPWR VPWR _2267_/X sky130_fd_sc_hd__o21a_1
XFILLER_72_408 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2198_ _3177_/Q _2129_/X _2197_/X VGND VGND VPWR VPWR _3177_/D sky130_fd_sc_hd__o21a_1
XFILLER_37_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_184 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_63 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_6 _2419_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3170_ _3398_/CLK _3170_/D VGND VGND VPWR VPWR _3170_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_39_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2121_ _2411_/B _2726_/B _2424_/D _2115_/X _2120_/X VGND VGND VPWR VPWR _2128_/D
+ sky130_fd_sc_hd__o311a_1
X_2052_ _3200_/Q _2459_/A _3288_/Q _2612_/B _1661_/X VGND VGND VPWR VPWR _2052_/X
+ sky130_fd_sc_hd__o2111a_1
XFILLER_19_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2954_ _2832_/A _3174_/Q _2953_/X _2816_/X VGND VGND VPWR VPWR _2954_/X sky130_fd_sc_hd__o211a_1
XFILLER_30_371 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2885_ _3365_/Q _2884_/X _2885_/S VGND VGND VPWR VPWR _3365_/D sky130_fd_sc_hd__mux2_1
X_1905_ _3144_/Q _3141_/Q _2884_/S VGND VGND VPWR VPWR _1905_/X sky130_fd_sc_hd__mux2_1
X_1836_ _1836_/A VGND VGND VPWR VPWR _2726_/B sky130_fd_sc_hd__buf_8
X_1767_ _3240_/Q _3241_/Q _3242_/Q _3243_/Q VGND VGND VPWR VPWR _1781_/D sky130_fd_sc_hd__nand4_2
X_1698_ _1815_/B _1815_/C VGND VGND VPWR VPWR _2020_/B sky130_fd_sc_hd__nor2_8
XTAP_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3368_ _3405_/CLK _3368_/D VGND VGND VPWR VPWR _3368_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2319_ _3190_/Q _2162_/X _2317_/X _2318_/X VGND VGND VPWR VPWR _2319_/X sky130_fd_sc_hd__a22o_1
XFILLER_66_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3299_ _3363_/CLK _3299_/D VGND VGND VPWR VPWR _3299_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_15_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput76 _3291_/Q VGND VGND VPWR VPWR o_wb_data[14] sky130_fd_sc_hd__clkbuf_1
Xoutput65 _1585_/X VGND VGND VPWR VPWR o_qspi_dat[2] sky130_fd_sc_hd__clkbuf_1
Xoutput98 _3306_/Q VGND VGND VPWR VPWR o_wb_data[5] sky130_fd_sc_hd__clkbuf_1
Xoutput87 _3319_/Q VGND VGND VPWR VPWR o_wb_data[24] sky130_fd_sc_hd__clkbuf_1
XFILLER_0_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_179 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2670_ _2335_/A _1661_/A _2492_/D _2460_/X _2669_/Y VGND VGND VPWR VPWR _2670_/X
+ sky130_fd_sc_hd__a221o_1
X_1621_ _2043_/B VGND VGND VPWR VPWR _1860_/D sky130_fd_sc_hd__inv_2
X_3222_ _3266_/CLK _3222_/D VGND VGND VPWR VPWR _3222_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_79_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3153_ _3356_/CLK _3153_/D VGND VGND VPWR VPWR _3153_/Q sky130_fd_sc_hd__dfxtp_1
X_2104_ _2801_/C _2738_/C _2451_/A _2741_/B VGND VGND VPWR VPWR _2104_/X sky130_fd_sc_hd__and4b_2
X_3084_ _3399_/Q _3396_/Q _3084_/S VGND VGND VPWR VPWR _3084_/X sky130_fd_sc_hd__mux2_1
X_2035_ _2035_/A _2035_/B _2035_/C _2035_/D VGND VGND VPWR VPWR _2055_/B sky130_fd_sc_hd__nand4_2
XFILLER_50_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_157 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_455 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2937_ _2934_/X _2826_/X _3100_/A _2936_/X VGND VGND VPWR VPWR _2937_/X sky130_fd_sc_hd__a211o_1
X_2868_ _3349_/Q _1911_/X _3331_/D VGND VGND VPWR VPWR _3349_/D sky130_fd_sc_hd__mux2_1
X_2799_ _3359_/Q _2888_/S _2801_/C VGND VGND VPWR VPWR _2799_/X sky130_fd_sc_hd__and3_1
X_1819_ input12/X _1819_/B _1819_/C VGND VGND VPWR VPWR _1819_/Y sky130_fd_sc_hd__nand3b_2
XTAP_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_352 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2722_ _3284_/Q input47/X _2725_/S VGND VGND VPWR VPWR _3284_/D sky130_fd_sc_hd__mux2_1
XFILLER_73_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2653_ _2594_/B _2651_/Y _2492_/C _2313_/X _2652_/X VGND VGND VPWR VPWR _2653_/X
+ sky130_fd_sc_hd__a311o_1
X_2584_ _2594_/B _2518_/X _2616_/C _2384_/C VGND VGND VPWR VPWR _3250_/D sky130_fd_sc_hd__o211a_1
X_1604_ _3254_/Q _3253_/Q VGND VGND VPWR VPWR _2520_/A sky130_fd_sc_hd__nor2_8
X_3205_ _3208_/CLK _3205_/D VGND VGND VPWR VPWR _3205_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_82_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3136_ _3338_/CLK _3136_/D VGND VGND VPWR VPWR _3136_/Q sky130_fd_sc_hd__dfxtp_1
X_3067_ _3167_/Q _3196_/Q VGND VGND VPWR VPWR _3067_/X sky130_fd_sc_hd__or2_1
X_2018_ _2018_/A _2018_/B _2018_/C VGND VGND VPWR VPWR _2018_/X sky130_fd_sc_hd__and3_1
XFILLER_82_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_260 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_230 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2705_ _3267_/Q input29/X _2717_/S VGND VGND VPWR VPWR _3267_/D sky130_fd_sc_hd__mux2_1
X_2636_ _2109_/A _2120_/C _2631_/Y _2095_/X _2635_/X VGND VGND VPWR VPWR _2637_/D
+ sky130_fd_sc_hd__a2111oi_1
X_2567_ input8/X _3240_/Q _2574_/S VGND VGND VPWR VPWR _3240_/D sky130_fd_sc_hd__mux2_1
X_2498_ _2520_/C _2411_/B _2102_/D _3256_/Q _1656_/X VGND VGND VPWR VPWR _2498_/X
+ sky130_fd_sc_hd__o311a_1
XFILLER_55_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3119_ _2831_/Y _2895_/A _3113_/X VGND VGND VPWR VPWR _3119_/X sky130_fd_sc_hd__o21a_1
XFILLER_55_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_185 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2421_ _2090_/X _2416_/X _2419_/X _2420_/X _2247_/D VGND VGND VPWR VPWR _2421_/X
+ sky130_fd_sc_hd__a221o_1
X_2352_ _3194_/Q _2389_/A _2733_/A _2389_/C VGND VGND VPWR VPWR _2352_/X sky130_fd_sc_hd__and4b_1
XFILLER_36_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2283_ _2520_/C _1644_/X _2257_/X _3244_/Q _2282_/X VGND VGND VPWR VPWR _2283_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_69_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_152 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1998_ _2448_/A _2448_/B _1998_/C _2448_/D VGND VGND VPWR VPWR _1998_/X sky130_fd_sc_hd__or4_1
XFILLER_69_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2619_ _3197_/Q _3199_/Q VGND VGND VPWR VPWR _2619_/Y sky130_fd_sc_hd__nor2_1
XFILLER_75_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_380 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_259 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2970_ _3380_/Q _3377_/Q _3093_/A VGND VGND VPWR VPWR _2970_/X sky130_fd_sc_hd__mux2_1
X_1921_ _3152_/Q _3149_/Q _2884_/S VGND VGND VPWR VPWR _1921_/X sky130_fd_sc_hd__mux2_1
X_1852_ _2577_/D _2120_/C _2075_/B _2053_/D VGND VGND VPWR VPWR _1852_/X sky130_fd_sc_hd__o31a_1
X_1783_ _2020_/B _1739_/X input22/X VGND VGND VPWR VPWR _2025_/B sky130_fd_sc_hd__o21ai_1
XFILLER_6_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2404_ _1808_/B _2164_/X _2403_/X _1626_/X _2090_/X VGND VGND VPWR VPWR _2404_/X
+ sky130_fd_sc_hd__a221o_1
X_3384_ _3389_/CLK _3384_/D VGND VGND VPWR VPWR _3384_/Q sky130_fd_sc_hd__dfxtp_1
X_2335_ _2335_/A _2335_/B _2335_/C VGND VGND VPWR VPWR _2335_/X sky130_fd_sc_hd__and3_1
X_2266_ _2389_/A _3185_/Q _2441_/A VGND VGND VPWR VPWR _2266_/X sky130_fd_sc_hd__a21bo_1
X_2197_ _1872_/B _2193_/X _2194_/X _2196_/X _2247_/D VGND VGND VPWR VPWR _2197_/X
+ sky130_fd_sc_hd__a311o_1
XFILLER_37_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_21 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_75 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_7 _2520_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2120_ _2726_/B _2120_/B _2120_/C _2119_/X VGND VGND VPWR VPWR _2120_/X sky130_fd_sc_hd__or4b_1
X_2051_ _2552_/B _2051_/B _2068_/C VGND VGND VPWR VPWR _2051_/X sky130_fd_sc_hd__or3_1
XFILLER_47_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2953_ _3055_/A _3177_/Q VGND VGND VPWR VPWR _2953_/X sky130_fd_sc_hd__or2_1
XFILLER_22_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1904_ _3144_/Q _1903_/X _1932_/S VGND VGND VPWR VPWR _3144_/D sky130_fd_sc_hd__mux2_1
XFILLER_30_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2884_ _3163_/Q _3160_/Q _2884_/S VGND VGND VPWR VPWR _2884_/X sky130_fd_sc_hd__mux2_1
X_1835_ _2043_/B _2740_/A VGND VGND VPWR VPWR _1836_/A sky130_fd_sc_hd__or2_1
X_1766_ _1815_/A _1766_/B VGND VGND VPWR VPWR _2021_/C sky130_fd_sc_hd__nor2_2
X_1697_ _3232_/Q _3233_/Q _3234_/Q _3235_/Q VGND VGND VPWR VPWR _1815_/C sky130_fd_sc_hd__nand4_4
XTAP_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3367_ _3405_/CLK _3367_/D VGND VGND VPWR VPWR _3367_/Q sky130_fd_sc_hd__dfxtp_2
XTAP_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2318_ _2318_/A _2324_/D _3239_/Q _2577_/D VGND VGND VPWR VPWR _2318_/X sky130_fd_sc_hd__or4_1
X_3298_ _3363_/CLK _3298_/D VGND VGND VPWR VPWR _3298_/Q sky130_fd_sc_hd__dfxtp_1
X_2249_ _3271_/Q _2552_/A _2576_/B _3263_/Q _2137_/X VGND VGND VPWR VPWR _2249_/X
+ sky130_fd_sc_hd__a221o_1
Xclkbuf_leaf_18_i_clk clkbuf_2_2__f_i_clk/X VGND VGND VPWR VPWR _3200_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_38_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput66 _1586_/X VGND VGND VPWR VPWR o_qspi_dat[3] sky130_fd_sc_hd__clkbuf_1
Xoutput88 _3320_/Q VGND VGND VPWR VPWR o_wb_data[25] sky130_fd_sc_hd__clkbuf_1
Xoutput77 _3292_/Q VGND VGND VPWR VPWR o_wb_data[15] sky130_fd_sc_hd__clkbuf_1
Xoutput99 _3307_/Q VGND VGND VPWR VPWR o_wb_data[6] sky130_fd_sc_hd__clkbuf_1
XFILLER_0_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_236 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1620_ _2726_/A VGND VGND VPWR VPWR _2318_/A sky130_fd_sc_hd__buf_12
X_3221_ _3266_/CLK _3221_/D VGND VGND VPWR VPWR _3221_/Q sky130_fd_sc_hd__dfxtp_1
X_3152_ _3356_/CLK _3152_/D VGND VGND VPWR VPWR _3152_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2103_ _2120_/B _2102_/D _2075_/B _2726_/B VGND VGND VPWR VPWR _2738_/C sky130_fd_sc_hd__o22a_1
X_3083_ _3399_/Q _2906_/X _3082_/X VGND VGND VPWR VPWR _3399_/D sky130_fd_sc_hd__a21o_1
X_2034_ _1772_/B _2027_/Y _2029_/Y _2030_/Y _2033_/Y VGND VGND VPWR VPWR _2035_/D
+ sky130_fd_sc_hd__o2111a_1
XFILLER_22_114 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2936_ _2832_/A _3171_/Q _2935_/X _2816_/X VGND VGND VPWR VPWR _2936_/X sky130_fd_sc_hd__o211a_1
XFILLER_22_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2867_ _3348_/Q _1909_/X _3331_/D VGND VGND VPWR VPWR _3348_/D sky130_fd_sc_hd__mux2_1
X_1818_ _3244_/Q _1818_/B VGND VGND VPWR VPWR _1819_/C sky130_fd_sc_hd__nand2_1
X_2798_ _3319_/Q _2747_/X _2797_/X VGND VGND VPWR VPWR _3319_/D sky130_fd_sc_hd__a21o_1
X_1749_ _1749_/A VGND VGND VPWR VPWR _1749_/Y sky130_fd_sc_hd__inv_2
XTAP_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_217 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2721_ _3283_/Q input46/X _2725_/S VGND VGND VPWR VPWR _3283_/D sky130_fd_sc_hd__mux2_1
XFILLER_8_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2652_ _2436_/C _1873_/B _2434_/X _1998_/C _2101_/C VGND VGND VPWR VPWR _2652_/X
+ sky130_fd_sc_hd__o32a_1
XFILLER_66_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2583_ _2740_/C _2389_/C _2188_/A _2717_/S VGND VGND VPWR VPWR _3249_/D sky130_fd_sc_hd__o22a_1
X_1603_ _3204_/Q VGND VGND VPWR VPWR _2086_/B sky130_fd_sc_hd__buf_4
X_3204_ _3204_/CLK _3204_/D VGND VGND VPWR VPWR _3204_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_79_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3135_ _3338_/CLK _3135_/D VGND VGND VPWR VPWR _3135_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_82_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_82_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3066_ _3396_/Q _3393_/Q _3084_/S VGND VGND VPWR VPWR _3066_/X sky130_fd_sc_hd__mux2_1
XFILLER_82_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2017_ _1720_/X _1721_/Y _1730_/B _1730_/A _1751_/A VGND VGND VPWR VPWR _2026_/A
+ sky130_fd_sc_hd__o221ai_1
XFILLER_42_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2919_ _3172_/Q _2907_/X _2909_/X _2918_/X VGND VGND VPWR VPWR _2919_/X sky130_fd_sc_hd__o211a_1
XFILLER_58_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_75 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2704_ _3266_/Q input28/X _2717_/S VGND VGND VPWR VPWR _3266_/D sky130_fd_sc_hd__mux2_1
X_2635_ _2335_/A _2838_/A _2456_/D _2632_/X _2634_/X VGND VGND VPWR VPWR _2635_/X
+ sky130_fd_sc_hd__a311o_1
X_2566_ input7/X _3239_/Q _2574_/S VGND VGND VPWR VPWR _3239_/D sky130_fd_sc_hd__mux2_1
X_2497_ _2499_/A _3125_/C VGND VGND VPWR VPWR _2497_/Y sky130_fd_sc_hd__nor2_2
XFILLER_59_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3118_ _2911_/X _3093_/B _3055_/A _2826_/A VGND VGND VPWR VPWR _3118_/X sky130_fd_sc_hd__o2bb2a_1
XFILLER_55_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3049_ _3055_/A _3193_/Q VGND VGND VPWR VPWR _3049_/X sky130_fd_sc_hd__or2_1
XFILLER_70_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2420_ _2188_/B _3200_/Q _2389_/A _2368_/X _2044_/X VGND VGND VPWR VPWR _2420_/X
+ sky130_fd_sc_hd__a311o_1
X_2351_ _1804_/B _2494_/A _2335_/C _2350_/X VGND VGND VPWR VPWR _2351_/X sky130_fd_sc_hd__a31o_1
X_2282_ _3274_/Q _2577_/D _2547_/C _2281_/X VGND VGND VPWR VPWR _2282_/X sky130_fd_sc_hd__o31a_1
XFILLER_29_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1997_ _1978_/B _1996_/X _2476_/S _2613_/A VGND VGND VPWR VPWR _1997_/X sky130_fd_sc_hd__o2bb2a_1
XFILLER_20_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2618_ _3331_/Q _3202_/Q _3201_/Q _2726_/B _2448_/D VGND VGND VPWR VPWR _2618_/X
+ sky130_fd_sc_hd__a311o_1
X_2549_ _2726_/B _2075_/B _1668_/D _2053_/D _2548_/X VGND VGND VPWR VPWR _2550_/A
+ sky130_fd_sc_hd__o221a_1
XFILLER_43_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1920_ _3152_/Q _1919_/X _1932_/S VGND VGND VPWR VPWR _3152_/D sky130_fd_sc_hd__mux2_1
X_1851_ _3255_/Q _2043_/B _1851_/C _2448_/D VGND VGND VPWR VPWR _2053_/D sky130_fd_sc_hd__or4_1
X_1782_ _3246_/Q _3247_/Q _2021_/C _1818_/B VGND VGND VPWR VPWR _1785_/A sky130_fd_sc_hd__nand4_1
X_3383_ _3389_/CLK _3383_/D VGND VGND VPWR VPWR _3383_/Q sky130_fd_sc_hd__dfxtp_1
X_2403_ _2397_/X _2398_/Y _2401_/X _2402_/X VGND VGND VPWR VPWR _2403_/X sky130_fd_sc_hd__a22o_1
XFILLER_69_201 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2334_ _2389_/C _1858_/X _2333_/Y _2335_/A _2740_/C VGND VGND VPWR VPWR _2334_/Y
+ sky130_fd_sc_hd__a311oi_2
X_2265_ _3185_/Q _2162_/X _2164_/X _1730_/B _2264_/X VGND VGND VPWR VPWR _2265_/X
+ sky130_fd_sc_hd__a221o_1
X_2196_ _2389_/C _1730_/B _2195_/X _1608_/X VGND VGND VPWR VPWR _2196_/X sky130_fd_sc_hd__o211a_1
XFILLER_1_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_465 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_86 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_8 _3334_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2050_ _2851_/B _2520_/B _2492_/A _1977_/A VGND VGND VPWR VPWR _2068_/C sky130_fd_sc_hd__a31o_1
XFILLER_47_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2952_ _3377_/Q _3374_/Q _3093_/A VGND VGND VPWR VPWR _2952_/X sky130_fd_sc_hd__mux2_1
XFILLER_22_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1903_ _3143_/Q _3140_/Q _2884_/S VGND VGND VPWR VPWR _1903_/X sky130_fd_sc_hd__mux2_1
X_2883_ _3364_/Q _1941_/X _2885_/S VGND VGND VPWR VPWR _3364_/D sky130_fd_sc_hd__mux2_1
X_1834_ _1692_/Y _2612_/C _1833_/X VGND VGND VPWR VPWR _1834_/Y sky130_fd_sc_hd__o21ai_1
X_1765_ _3245_/Q VGND VGND VPWR VPWR _1766_/B sky130_fd_sc_hd__clkinv_2
X_1696_ _1815_/B _1695_/Y _3288_/Q _2740_/B _2739_/A VGND VGND VPWR VPWR _1827_/A
+ sky130_fd_sc_hd__o2111a_1
X_3366_ _3366_/CLK _3366_/D VGND VGND VPWR VPWR _3366_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2317_ _3247_/Q _2190_/D _2312_/X _1955_/C _2316_/X VGND VGND VPWR VPWR _2317_/X
+ sky130_fd_sc_hd__a311o_1
X_3297_ _3363_/CLK _3297_/D VGND VGND VPWR VPWR _3297_/Q sky130_fd_sc_hd__dfxtp_1
X_2248_ _3183_/Q _2129_/X _2247_/X VGND VGND VPWR VPWR _3183_/D sky130_fd_sc_hd__o21a_1
XFILLER_38_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2179_ _3175_/Q _2129_/X _2178_/X VGND VGND VPWR VPWR _3175_/D sky130_fd_sc_hd__o21a_1
XFILLER_25_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput67 _1580_/X VGND VGND VPWR VPWR o_qspi_mod[0] sky130_fd_sc_hd__clkbuf_1
Xoutput89 _3321_/Q VGND VGND VPWR VPWR o_wb_data[26] sky130_fd_sc_hd__clkbuf_1
Xoutput78 _3293_/Q VGND VGND VPWR VPWR o_wb_data[16] sky130_fd_sc_hd__clkbuf_1
XFILLER_48_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3220_ _3266_/CLK _3220_/D VGND VGND VPWR VPWR _3220_/Q sky130_fd_sc_hd__dfxtp_1
X_3151_ _3353_/CLK _3151_/D VGND VGND VPWR VPWR _3151_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_11_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2102_ _2726_/A _2424_/A _2434_/B _2102_/D VGND VGND VPWR VPWR _2543_/C sky130_fd_sc_hd__or4_4
X_3082_ _3199_/Q _2907_/A _2909_/X _3081_/X VGND VGND VPWR VPWR _3082_/X sky130_fd_sc_hd__o211a_1
XFILLER_35_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2033_ input9/X _2031_/X _2032_/Y VGND VGND VPWR VPWR _2033_/Y sky130_fd_sc_hd__a21oi_1
XFILLER_35_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2935_ _3055_/A _3174_/Q VGND VGND VPWR VPWR _2935_/X sky130_fd_sc_hd__or2_1
X_2866_ _3347_/Q _1907_/X _3331_/D VGND VGND VPWR VPWR _3347_/D sky130_fd_sc_hd__mux2_1
X_1817_ _1810_/B _1810_/C _1796_/B _3244_/Q VGND VGND VPWR VPWR _1819_/B sky130_fd_sc_hd__a31o_1
X_2797_ _3358_/Q _2888_/S _2801_/C VGND VGND VPWR VPWR _2797_/X sky130_fd_sc_hd__and3_1
X_1748_ _1748_/A _1749_/A VGND VGND VPWR VPWR _1751_/A sky130_fd_sc_hd__nand2_1
X_1679_ _2040_/B _1679_/B VGND VGND VPWR VPWR _1679_/Y sky130_fd_sc_hd__nand2_1
X_3349_ _3350_/CLK _3349_/D VGND VGND VPWR VPWR _3349_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_229 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2720_ _3282_/Q input45/X _2725_/S VGND VGND VPWR VPWR _3282_/D sky130_fd_sc_hd__mux2_1
XFILLER_8_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2651_ _3409_/Q _3408_/Q _3262_/Q VGND VGND VPWR VPWR _2651_/Y sky130_fd_sc_hd__o21bai_1
Xclkbuf_leaf_17_i_clk _3228_/CLK VGND VGND VPWR VPWR _3204_/CLK sky130_fd_sc_hd__clkbuf_16
X_1602_ _2441_/A VGND VGND VPWR VPWR _2389_/C sky130_fd_sc_hd__clkbuf_16
X_2582_ _2725_/S VGND VGND VPWR VPWR _2717_/S sky130_fd_sc_hd__clkbuf_16
XFILLER_59_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3203_ _3203_/CLK _3203_/D VGND VGND VPWR VPWR _3203_/Q sky130_fd_sc_hd__dfxtp_4
XFILLER_79_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3134_ _3338_/CLK _3134_/D VGND VGND VPWR VPWR _3134_/Q sky130_fd_sc_hd__dfxtp_1
X_3065_ _3396_/Q _2906_/X _3064_/X VGND VGND VPWR VPWR _3396_/D sky130_fd_sc_hd__a21o_1
X_2016_ input13/X _1793_/Y _1794_/Y _2014_/Y _2015_/X VGND VGND VPWR VPWR _2035_/B
+ sky130_fd_sc_hd__o311a_1
X_2918_ _3171_/Q _2910_/X _2911_/X _3371_/Q _2922_/A VGND VGND VPWR VPWR _2918_/X
+ sky130_fd_sc_hd__a221o_1
X_2849_ _2844_/X _2841_/X _2848_/X _2846_/X _2884_/S VGND VGND VPWR VPWR _3330_/D
+ sky130_fd_sc_hd__a32o_1
XFILLER_12_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_43 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2703_ _3265_/Q input58/X _2717_/S VGND VGND VPWR VPWR _3265_/D sky130_fd_sc_hd__mux2_1
X_2634_ _2616_/D _1661_/A _2633_/X _2052_/X VGND VGND VPWR VPWR _2634_/X sky130_fd_sc_hd__a31o_1
X_2565_ input6/X _3238_/Q _2574_/S VGND VGND VPWR VPWR _3238_/D sky130_fd_sc_hd__mux2_1
X_2496_ _2496_/A _2496_/B _2496_/C _2496_/D VGND VGND VPWR VPWR _3125_/C sky130_fd_sc_hd__or4_2
XFILLER_59_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3117_ _3100_/A _3115_/X _3116_/X _3406_/Q VGND VGND VPWR VPWR _3406_/D sky130_fd_sc_hd__a2bb2o_1
XFILLER_82_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_176 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3048_ _3393_/Q _3390_/Q _3084_/S VGND VGND VPWR VPWR _3048_/X sky130_fd_sc_hd__mux2_1
XFILLER_70_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2350_ _2520_/B _1854_/Y _2346_/X _2349_/X VGND VGND VPWR VPWR _2350_/X sky130_fd_sc_hd__a31o_1
X_2281_ _3272_/Q _2109_/A _2552_/A _2280_/X VGND VGND VPWR VPWR _2281_/X sky130_fd_sc_hd__a211o_1
XFILLER_37_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1996_ _1858_/X _2612_/B _2097_/A _1995_/X VGND VGND VPWR VPWR _1996_/X sky130_fd_sc_hd__a211o_1
X_2617_ _2318_/A _1974_/X _2545_/X _2615_/X _2616_/X VGND VGND VPWR VPWR _2637_/B
+ sky130_fd_sc_hd__a311oi_1
X_2548_ _3255_/Q _2612_/B _2114_/D _2324_/D VGND VGND VPWR VPWR _2548_/X sky130_fd_sc_hd__a211o_1
X_2479_ _3207_/Q VGND VGND VPWR VPWR _2479_/Y sky130_fd_sc_hd__inv_2
XFILLER_18_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1850_ _1850_/A VGND VGND VPWR VPWR _2075_/B sky130_fd_sc_hd__buf_4
X_1781_ _1815_/B _1815_/C _1809_/C _1781_/D VGND VGND VPWR VPWR _1818_/B sky130_fd_sc_hd__nor4_4
X_3382_ _3389_/CLK _3382_/D VGND VGND VPWR VPWR _3382_/Q sky130_fd_sc_hd__dfxtp_1
X_2402_ _2318_/A _2448_/B _2324_/D _3247_/Q _2741_/C VGND VGND VPWR VPWR _2402_/X
+ sky130_fd_sc_hd__o32a_1
X_2333_ _3203_/Q _2086_/B _3193_/Q _2733_/A VGND VGND VPWR VPWR _2333_/Y sky130_fd_sc_hd__o211ai_1
XFILLER_69_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2264_ _3234_/Q _2577_/D _2120_/B _2263_/X VGND VGND VPWR VPWR _2264_/X sky130_fd_sc_hd__o31a_1
X_2195_ _2389_/A _3177_/Q _2441_/A VGND VGND VPWR VPWR _2195_/X sky130_fd_sc_hd__a21bo_1
XFILLER_1_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_102 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1979_ _2492_/C _2581_/A _2070_/C _1978_/X VGND VGND VPWR VPWR _1980_/S sky130_fd_sc_hd__or4b_1
XFILLER_43_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_98 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_282 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2951_ _3377_/Q _2906_/X _2950_/X VGND VGND VPWR VPWR _3377_/D sky130_fd_sc_hd__a21o_1
X_1902_ _3143_/Q _1901_/X _1932_/S VGND VGND VPWR VPWR _3143_/D sky130_fd_sc_hd__mux2_1
XFILLER_15_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2882_ _3363_/Q _1939_/X _2885_/S VGND VGND VPWR VPWR _3363_/D sky130_fd_sc_hd__mux2_1
X_1833_ _2492_/C _2436_/A _2612_/D _3122_/D VGND VGND VPWR VPWR _1833_/X sky130_fd_sc_hd__or4_1
X_1764_ _3244_/Q VGND VGND VPWR VPWR _1815_/A sky130_fd_sc_hd__inv_2
X_1695_ _3232_/Q _3233_/Q VGND VGND VPWR VPWR _1695_/Y sky130_fd_sc_hd__nand2_2
XTAP_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3365_ _3365_/CLK _3365_/D VGND VGND VPWR VPWR _3365_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3296_ _3353_/CLK _3296_/D VGND VGND VPWR VPWR _3296_/Q sky130_fd_sc_hd__dfxtp_1
X_2316_ _2448_/B _2547_/C _3247_/Q _2001_/X _2315_/X VGND VGND VPWR VPWR _2316_/X
+ sky130_fd_sc_hd__o311a_1
X_2247_ _2247_/A _2247_/B _2247_/C _2247_/D VGND VGND VPWR VPWR _2247_/X sky130_fd_sc_hd__or4_1
X_2178_ _1872_/B _2174_/X _2175_/X _2177_/X _2247_/D VGND VGND VPWR VPWR _2178_/X
+ sky130_fd_sc_hd__a311o_1
XFILLER_25_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput79 _3294_/Q VGND VGND VPWR VPWR o_wb_data[17] sky130_fd_sc_hd__clkbuf_1
Xoutput68 _1582_/X VGND VGND VPWR VPWR o_qspi_mod[1] sky130_fd_sc_hd__clkbuf_1
XFILLER_56_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_352 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3150_ _3353_/CLK _3150_/D VGND VGND VPWR VPWR _3150_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_39_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3081_ _3078_/X _2826_/X _2922_/A _3080_/X VGND VGND VPWR VPWR _3081_/X sky130_fd_sc_hd__a211o_1
X_2101_ _2096_/X _2101_/B _2101_/C VGND VGND VPWR VPWR _2128_/A sky130_fd_sc_hd__and3b_1
X_2032_ _1804_/B _1818_/B _1802_/Y input9/X _2031_/X VGND VGND VPWR VPWR _2032_/Y
+ sky130_fd_sc_hd__o32ai_1
XFILLER_35_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2934_ _3374_/Q _3371_/Q _3093_/A VGND VGND VPWR VPWR _2934_/X sky130_fd_sc_hd__mux2_1
X_2865_ _3346_/Q _1905_/X _3331_/D VGND VGND VPWR VPWR _3346_/D sky130_fd_sc_hd__mux2_1
X_1816_ _1814_/Y _1815_/Y input12/X VGND VGND VPWR VPWR _1816_/Y sky130_fd_sc_hd__o21ai_2
X_2796_ _3318_/Q _2747_/X _2795_/X VGND VGND VPWR VPWR _3318_/D sky130_fd_sc_hd__a21o_1
X_1747_ _1815_/B _1695_/Y _1746_/Y VGND VGND VPWR VPWR _1748_/A sky130_fd_sc_hd__o21ai_1
X_1678_ _2188_/A _1630_/Y _1677_/Y VGND VGND VPWR VPWR _2040_/B sky130_fd_sc_hd__o21ai_1
X_3348_ _3350_/CLK _3348_/D VGND VGND VPWR VPWR _3348_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3279_ _3409_/CLK _3279_/D VGND VGND VPWR VPWR _3279_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_26_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_0_i_clk i_clk VGND VGND VPWR VPWR clkbuf_0_i_clk/X sky130_fd_sc_hd__clkbuf_16
XFILLER_17_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2650_ _2318_/A _2520_/A _2520_/B _1647_/X VGND VGND VPWR VPWR _2650_/X sky130_fd_sc_hd__a31o_1
XFILLER_8_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1601_ _2739_/A VGND VGND VPWR VPWR _2441_/A sky130_fd_sc_hd__buf_8
X_2581_ _2581_/A _2581_/B _2581_/C _2580_/X VGND VGND VPWR VPWR _2725_/S sky130_fd_sc_hd__nor4b_4
X_3202_ _3398_/CLK _3202_/D VGND VGND VPWR VPWR _3202_/Q sky130_fd_sc_hd__dfxtp_4
XFILLER_67_344 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3133_ _3356_/CLK _3133_/D VGND VGND VPWR VPWR _3133_/Q sky130_fd_sc_hd__dfxtp_1
X_3064_ _3196_/Q _2907_/X _2909_/X _3063_/X VGND VGND VPWR VPWR _3064_/X sky130_fd_sc_hd__o211a_1
X_2015_ input7/X _1786_/X _1788_/Y _1816_/Y _1819_/Y VGND VGND VPWR VPWR _2015_/X
+ sky130_fd_sc_hd__o311a_1
XFILLER_23_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2917_ _3371_/Q _2906_/X _2916_/X VGND VGND VPWR VPWR _3371_/D sky130_fd_sc_hd__a21o_1
XFILLER_12_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2848_ _3093_/A _2895_/A _2827_/X VGND VGND VPWR VPWR _2848_/X sky130_fd_sc_hd__a21o_1
X_2779_ _3343_/Q _2888_/S _2801_/C VGND VGND VPWR VPWR _2779_/X sky130_fd_sc_hd__and3_1
XTAP_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_447 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_406 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2702_ _3264_/Q input57/X _2717_/S VGND VGND VPWR VPWR _3264_/D sky130_fd_sc_hd__mux2_1
XFILLER_71_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2633_ _2851_/B _2633_/B _3201_/Q _3202_/Q VGND VGND VPWR VPWR _2633_/X sky130_fd_sc_hd__or4bb_1
X_2564_ _1821_/B _3237_/Q _2574_/S VGND VGND VPWR VPWR _3237_/D sky130_fd_sc_hd__mux2_1
X_2495_ _1854_/Y _1873_/B _2552_/A _2494_/X VGND VGND VPWR VPWR _2496_/D sky130_fd_sc_hd__a211o_1
XFILLER_67_130 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3116_ _3093_/A _2895_/A _3114_/X VGND VGND VPWR VPWR _3116_/X sky130_fd_sc_hd__a21o_1
XFILLER_67_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3047_ _3393_/Q _2906_/X _3046_/X VGND VGND VPWR VPWR _3393_/D sky130_fd_sc_hd__a21o_1
XFILLER_23_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_55 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_347 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_122 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_443 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2280_ _2594_/B _3258_/Q _2492_/C _2576_/B _3214_/Q VGND VGND VPWR VPWR _2280_/X
+ sky130_fd_sc_hd__a32o_1
XFILLER_52_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1995_ _2740_/A _2726_/C _3255_/Q _2043_/B VGND VGND VPWR VPWR _1995_/X sky130_fd_sc_hd__or4bb_1
XFILLER_20_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2616_ _2739_/C _2616_/B _2616_/C _2616_/D VGND VGND VPWR VPWR _2616_/X sky130_fd_sc_hd__and4b_1
X_2547_ _2547_/A _2547_/B _2547_/C VGND VGND VPWR VPWR _2581_/C sky130_fd_sc_hd__and3_1
X_2478_ _3205_/Q _2478_/B VGND VGND VPWR VPWR _2478_/X sky130_fd_sc_hd__or2_1
XFILLER_55_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_424 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1780_ _1780_/A _1780_/B VGND VGND VPWR VPWR _1780_/Y sky130_fd_sc_hd__nand2_1
XFILLER_6_240 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3381_ _3389_/CLK _3381_/D VGND VGND VPWR VPWR _3381_/Q sky130_fd_sc_hd__dfxtp_1
X_2401_ _2335_/A _2187_/X _2399_/X _2400_/X VGND VGND VPWR VPWR _2401_/X sky130_fd_sc_hd__o211a_1
X_2332_ _2331_/X _2129_/X _2123_/X _3192_/Q VGND VGND VPWR VPWR _3192_/D sky130_fd_sc_hd__a22o_1
XFILLER_69_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2263_ _2520_/C _1644_/X _2257_/X _3242_/Q _2262_/X VGND VGND VPWR VPWR _2263_/X
+ sky130_fd_sc_hd__a221o_1
X_2194_ _2188_/B _3177_/Q _2389_/A _2044_/X VGND VGND VPWR VPWR _2194_/X sky130_fd_sc_hd__a31o_1
XFILLER_37_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_114 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1978_ _2801_/C _1978_/B _1978_/C _2741_/B VGND VGND VPWR VPWR _1978_/X sky130_fd_sc_hd__and4b_1
XFILLER_20_48 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_291 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2950_ _3177_/Q _2907_/X _2909_/X _2949_/X VGND VGND VPWR VPWR _2950_/X sky130_fd_sc_hd__o211a_1
XFILLER_22_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2881_ _3362_/Q _1937_/X _2885_/S VGND VGND VPWR VPWR _3362_/D sky130_fd_sc_hd__mux2_1
X_1901_ _3142_/Q _3139_/Q _2884_/S VGND VGND VPWR VPWR _1901_/X sky130_fd_sc_hd__mux2_1
X_1832_ _2726_/A _1665_/A _2313_/C _2616_/D VGND VGND VPWR VPWR _3122_/D sky130_fd_sc_hd__a22o_1
X_1763_ _1708_/Y _1713_/X _2013_/B _1737_/X _1762_/Y VGND VGND VPWR VPWR _1827_/B
+ sky130_fd_sc_hd__o2111a_1
X_1694_ _1694_/A VGND VGND VPWR VPWR _1815_/B sky130_fd_sc_hd__buf_6
XTAP_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3364_ _3366_/CLK _3364_/D VGND VGND VPWR VPWR _3364_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3295_ _3353_/CLK _3295_/D VGND VGND VPWR VPWR _3295_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2315_ _3277_/Q _2552_/A _2552_/C _2314_/X VGND VGND VPWR VPWR _2315_/X sky130_fd_sc_hd__a211o_1
XTAP_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2246_ input19/X _2494_/A _2335_/C _2162_/X _3183_/Q VGND VGND VPWR VPWR _2247_/C
+ sky130_fd_sc_hd__a32o_1
X_2177_ _2389_/C input19/X _2176_/X _1608_/X VGND VGND VPWR VPWR _2177_/X sky130_fd_sc_hd__o211a_1
XFILLER_25_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput69 _1579_/X VGND VGND VPWR VPWR o_qspi_sck sky130_fd_sc_hd__clkbuf_1
XFILLER_29_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3080_ _2832_/A _3195_/Q _3079_/X _2816_/A VGND VGND VPWR VPWR _3080_/X sky130_fd_sc_hd__o211a_1
XFILLER_39_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2100_ _2448_/A _2726_/B _2726_/C VGND VGND VPWR VPWR _2101_/C sky130_fd_sc_hd__or3_1
X_2031_ _2020_/B _1715_/C _2020_/D _1810_/Y _1710_/Y VGND VGND VPWR VPWR _2031_/X
+ sky130_fd_sc_hd__a32o_1
XFILLER_54_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2933_ _3374_/Q _2906_/X _2932_/X VGND VGND VPWR VPWR _3374_/D sky130_fd_sc_hd__a21o_1
XFILLER_22_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2864_ _3345_/Q _1903_/X _3331_/D VGND VGND VPWR VPWR _3345_/D sky130_fd_sc_hd__mux2_1
XFILLER_30_172 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2795_ _3357_/Q _2888_/S _2801_/C VGND VGND VPWR VPWR _2795_/X sky130_fd_sc_hd__and3_1
X_1815_ _1815_/A _1815_/B _1815_/C _1796_/B VGND VGND VPWR VPWR _1815_/Y sky130_fd_sc_hd__nor4b_1
X_1746_ _1745_/Y _1815_/B _3233_/Q VGND VGND VPWR VPWR _1746_/Y sky130_fd_sc_hd__o21bai_1
X_1677_ _3287_/Q _2463_/C _1676_/Y _2188_/A _1679_/B VGND VGND VPWR VPWR _1677_/Y
+ sky130_fd_sc_hd__o2111ai_4
X_3347_ _3350_/CLK _3347_/D VGND VGND VPWR VPWR _3347_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3278_ _3278_/CLK _3278_/D VGND VGND VPWR VPWR _3278_/Q sky130_fd_sc_hd__dfxtp_1
X_2229_ _2389_/A _3181_/Q _2441_/A VGND VGND VPWR VPWR _2229_/X sky130_fd_sc_hd__a21bo_1
XFILLER_26_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_426 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_18 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1600_ _1600_/A VGND VGND VPWR VPWR _2739_/A sky130_fd_sc_hd__buf_6
X_2580_ _2318_/A _2448_/B _2726_/C _2075_/B _2548_/X VGND VGND VPWR VPWR _2580_/X
+ sky130_fd_sc_hd__o311a_1
XFILLER_4_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3201_ _3398_/CLK _3201_/D VGND VGND VPWR VPWR _3201_/Q sky130_fd_sc_hd__dfxtp_4
X_3132_ _3255_/CLK _3132_/D VGND VGND VPWR VPWR _3132_/Q sky130_fd_sc_hd__dfxtp_2
XFILLER_67_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_356 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3063_ _3060_/X _2826_/X _3100_/A _3062_/X VGND VGND VPWR VPWR _3063_/X sky130_fd_sc_hd__a211o_1
X_2014_ _1786_/X _1788_/Y input7/X VGND VGND VPWR VPWR _2014_/Y sky130_fd_sc_hd__o21ai_1
X_2916_ _3171_/Q _2907_/X _2909_/X _2915_/X VGND VGND VPWR VPWR _2916_/X sky130_fd_sc_hd__o211a_1
X_2847_ _2844_/X _2841_/X _2845_/X _2846_/X _3329_/Q VGND VGND VPWR VPWR _3329_/D
+ sky130_fd_sc_hd__a32o_1
XFILLER_12_38 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2778_ _3309_/Q _2747_/X _2777_/X VGND VGND VPWR VPWR _3309_/D sky130_fd_sc_hd__a21o_1
X_1729_ _1729_/A _1729_/B VGND VGND VPWR VPWR _1730_/A sky130_fd_sc_hd__nand2_1
XTAP_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_459 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_348 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2701_ _3263_/Q input56/X _2717_/S VGND VGND VPWR VPWR _3263_/D sky130_fd_sc_hd__mux2_1
X_2632_ _2459_/A _3202_/Q _3201_/Q _1966_/X _2436_/A VGND VGND VPWR VPWR _2632_/X
+ sky130_fd_sc_hd__o311a_1
X_2563_ input23/X _3236_/Q _2574_/S VGND VGND VPWR VPWR _3236_/D sky130_fd_sc_hd__mux2_1
X_2494_ _2494_/A _2494_/B _2494_/C _2494_/D VGND VGND VPWR VPWR _2494_/X sky130_fd_sc_hd__or4_1
XFILLER_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_142 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3115_ _3055_/A _2816_/X _3113_/X _3114_/X VGND VGND VPWR VPWR _3115_/X sky130_fd_sc_hd__a211o_1
XFILLER_67_175 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3046_ _3193_/Q _2907_/X _2909_/X _3045_/X VGND VGND VPWR VPWR _3046_/X sky130_fd_sc_hd__o211a_1
XFILLER_55_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_134 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_455 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_395 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1994_ _2616_/D _1994_/B _1994_/C VGND VGND VPWR VPWR _2668_/B sky130_fd_sc_hd__or3_2
X_2615_ _2671_/A _2851_/B _2436_/C _1854_/Y VGND VGND VPWR VPWR _2615_/X sky130_fd_sc_hd__o211a_1
X_2546_ _2545_/X _2612_/C _1974_/X _2318_/A VGND VGND VPWR VPWR _2581_/B sky130_fd_sc_hd__o211a_1
X_2477_ _3242_/Q VGND VGND VPWR VPWR _2478_/B sky130_fd_sc_hd__inv_2
XFILLER_28_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3029_ _3390_/Q _2906_/X _3028_/X VGND VGND VPWR VPWR _3390_/D sky130_fd_sc_hd__a21o_1
XFILLER_55_189 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_436 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_22 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2400_ _3248_/Q _2001_/X _2382_/X _2190_/X VGND VGND VPWR VPWR _2400_/X sky130_fd_sc_hd__o211a_1
X_3380_ _3389_/CLK _3380_/D VGND VGND VPWR VPWR _3380_/Q sky130_fd_sc_hd__dfxtp_1
X_2331_ _3192_/Q _2162_/X _2164_/X input9/X _2330_/X VGND VGND VPWR VPWR _2331_/X
+ sky130_fd_sc_hd__a221o_1
X_2262_ _3272_/Q _2577_/D _2547_/C _2261_/X VGND VGND VPWR VPWR _2262_/X sky130_fd_sc_hd__o31a_1
XFILLER_77_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2193_ _2384_/C _2594_/B _1854_/Y _2191_/X _2192_/X VGND VGND VPWR VPWR _2193_/X
+ sky130_fd_sc_hd__a32o_1
XFILLER_80_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_126 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1977_ _1977_/A _3122_/B _1977_/C _1977_/D VGND VGND VPWR VPWR _1978_/C sky130_fd_sc_hd__nor4_1
XFILLER_20_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_15_i_clk _3228_/CLK VGND VGND VPWR VPWR _3365_/CLK sky130_fd_sc_hd__clkbuf_16
X_2529_ _3221_/Q _2533_/D _2528_/X VGND VGND VPWR VPWR _3221_/D sky130_fd_sc_hd__a21bo_1
XFILLER_56_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1900_ _3142_/Q _1899_/X _1932_/S VGND VGND VPWR VPWR _3142_/D sky130_fd_sc_hd__mux2_1
XFILLER_15_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2880_ _3361_/Q _1935_/X _2885_/S VGND VGND VPWR VPWR _3361_/D sky130_fd_sc_hd__mux2_1
X_1831_ _1831_/A _2448_/D VGND VGND VPWR VPWR _2313_/C sky130_fd_sc_hd__nor2_2
XFILLER_30_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1762_ _1762_/A _1762_/B _1762_/C VGND VGND VPWR VPWR _1762_/Y sky130_fd_sc_hd__nor3_1
X_1693_ _2585_/A _2368_/B _3230_/Q _3231_/Q VGND VGND VPWR VPWR _1694_/A sky130_fd_sc_hd__nand4_1
X_3363_ _3363_/CLK _3363_/D VGND VGND VPWR VPWR _3363_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3294_ _3353_/CLK _3294_/D VGND VGND VPWR VPWR _3294_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2314_ _3275_/Q _2109_/A _2576_/B _3408_/Q _2313_/X VGND VGND VPWR VPWR _2314_/X
+ sky130_fd_sc_hd__a221o_1
X_2245_ _2441_/A input8/X _2244_/X _1608_/X VGND VGND VPWR VPWR _2247_/B sky130_fd_sc_hd__o211a_1
X_2176_ _2389_/A _3175_/Q _2441_/A VGND VGND VPWR VPWR _2176_/X sky130_fd_sc_hd__a21bo_1
XFILLER_25_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_347 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2030_ _1818_/B _1802_/Y _1804_/B VGND VGND VPWR VPWR _2030_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_47_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2932_ _3174_/Q _2907_/X _2909_/X _2931_/X VGND VGND VPWR VPWR _2932_/X sky130_fd_sc_hd__o211a_1
XFILLER_50_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2863_ _3344_/Q _1901_/X _3331_/D VGND VGND VPWR VPWR _3344_/D sky130_fd_sc_hd__mux2_1
X_2794_ _3317_/Q _2747_/X _2793_/X VGND VGND VPWR VPWR _3317_/D sky130_fd_sc_hd__a21o_1
XFILLER_30_184 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1814_ _2020_/B _1796_/B _3244_/Q VGND VGND VPWR VPWR _1814_/Y sky130_fd_sc_hd__a21oi_1
X_1745_ _3232_/Q VGND VGND VPWR VPWR _1745_/Y sky130_fd_sc_hd__inv_2
XFILLER_7_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1676_ _2585_/A _2368_/B VGND VGND VPWR VPWR _1676_/Y sky130_fd_sc_hd__nand2_1
X_3346_ _3350_/CLK _3346_/D VGND VGND VPWR VPWR _3346_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3277_ _3287_/CLK _3277_/D VGND VGND VPWR VPWR _3277_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2228_ _3181_/Q _2162_/X _2164_/X input17/X _2227_/X VGND VGND VPWR VPWR _2228_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_38_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2159_ _1872_/B _2155_/X _2156_/X _2158_/X _2247_/D VGND VGND VPWR VPWR _2159_/X
+ sky130_fd_sc_hd__a311o_1
XFILLER_53_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_435 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3200_ _3200_/CLK _3200_/D VGND VGND VPWR VPWR _3200_/Q sky130_fd_sc_hd__dfxtp_4
XFILLER_79_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3131_ _3255_/CLK _3131_/D VGND VGND VPWR VPWR _3131_/Q sky130_fd_sc_hd__dfxtp_2
XFILLER_67_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3062_ _2832_/A _3192_/Q _3061_/X _2816_/X VGND VGND VPWR VPWR _3062_/X sky130_fd_sc_hd__o211a_1
XFILLER_67_368 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2013_ _2013_/A _2013_/B _2013_/C _2013_/D VGND VGND VPWR VPWR _2035_/A sky130_fd_sc_hd__and4_1
X_2915_ _3170_/Q _2910_/X _2911_/X _3370_/Q _2922_/A VGND VGND VPWR VPWR _2915_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_31_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2846_ _2838_/A _2827_/B _2818_/Y _2825_/B VGND VGND VPWR VPWR _2846_/X sky130_fd_sc_hd__a211o_1
X_2777_ _3342_/Q _2888_/S _2801_/C VGND VGND VPWR VPWR _2777_/X sky130_fd_sc_hd__and3_1
XFILLER_2_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1728_ _1815_/B _1695_/Y _1727_/Y VGND VGND VPWR VPWR _1729_/B sky130_fd_sc_hd__o21ai_1
X_1659_ _1659_/A VGND VGND VPWR VPWR _2448_/D sky130_fd_sc_hd__buf_4
XTAP_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3329_ _3405_/CLK _3329_/D VGND VGND VPWR VPWR _3329_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_276 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2700_ _3262_/Q input55/X _2717_/S VGND VGND VPWR VPWR _3262_/D sky130_fd_sc_hd__mux2_1
X_2631_ _2613_/A _2628_/X _2629_/X _2630_/X _2112_/C VGND VGND VPWR VPWR _2631_/Y
+ sky130_fd_sc_hd__o221ai_1
X_2562_ input22/X _3235_/Q _2574_/S VGND VGND VPWR VPWR _3235_/D sky130_fd_sc_hd__mux2_1
X_2493_ _2460_/X _2291_/X _2576_/B _2612_/D VGND VGND VPWR VPWR _2494_/D sky130_fd_sc_hd__a211o_1
XFILLER_67_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3114_ _2838_/A _2922_/A _2825_/B _3093_/A _2906_/A VGND VGND VPWR VPWR _3114_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_67_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3045_ _3042_/X _2826_/X _3100_/A _3044_/X VGND VGND VPWR VPWR _3045_/X sky130_fd_sc_hd__a211o_1
XFILLER_67_187 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2829_ _2829_/A VGND VGND VPWR VPWR _2829_/Y sky130_fd_sc_hd__clkinv_2
XFILLER_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_360 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_374 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1993_ _2424_/A _2448_/A VGND VGND VPWR VPWR _1994_/C sky130_fd_sc_hd__or2_1
X_2614_ _3167_/Q VGND VGND VPWR VPWR _2671_/A sky130_fd_sc_hd__inv_2
X_2545_ _3165_/Q _2612_/B VGND VGND VPWR VPWR _2545_/X sky130_fd_sc_hd__and2_1
X_2476_ _3275_/Q _3210_/Q _2476_/S VGND VGND VPWR VPWR _3210_/D sky130_fd_sc_hd__mux2_1
XFILLER_68_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3028_ _3190_/Q _2907_/X _2909_/X _3027_/X VGND VGND VPWR VPWR _3028_/X sky130_fd_sc_hd__o211a_1
XFILLER_36_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_127 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_58 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_34 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_11 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_146 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_385 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2330_ _3279_/Q _1844_/B _2741_/C _3241_/Q _2329_/X VGND VGND VPWR VPWR _2330_/X
+ sky130_fd_sc_hd__o221a_1
X_2261_ _3270_/Q _2109_/A _2552_/A _2260_/X VGND VGND VPWR VPWR _2261_/X sky130_fd_sc_hd__a211o_1
XFILLER_1_30 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2192_ _3264_/Q _2552_/A _2576_/B _3256_/Q _2137_/X VGND VGND VPWR VPWR _2192_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_37_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1976_ _3334_/Q _2097_/A _3331_/Q _2051_/B VGND VGND VPWR VPWR _1977_/D sky130_fd_sc_hd__o211a_1
XFILLER_60_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2528_ _2318_/A _2411_/B _2726_/B _3221_/Q _2533_/D VGND VGND VPWR VPWR _2528_/X
+ sky130_fd_sc_hd__o32a_1
XFILLER_0_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2459_ _2459_/A _3334_/Q _1959_/Y VGND VGND VPWR VPWR _2459_/X sky130_fd_sc_hd__or3b_1
XFILLER_28_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_403 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1830_ _1830_/A VGND VGND VPWR VPWR _2492_/C sky130_fd_sc_hd__buf_4
X_1761_ _1730_/B _1730_/A _2018_/B _2018_/C _2018_/A VGND VGND VPWR VPWR _1762_/C
+ sky130_fd_sc_hd__o2111ai_1
X_1692_ _2612_/B _2612_/D VGND VGND VPWR VPWR _1692_/Y sky130_fd_sc_hd__nand2_1
X_3362_ _3366_/CLK _3362_/D VGND VGND VPWR VPWR _3362_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2313_ _3261_/Q _2520_/B _2313_/C VGND VGND VPWR VPWR _2313_/X sky130_fd_sc_hd__and3_1
XTAP_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3293_ _3353_/CLK _3293_/D VGND VGND VPWR VPWR _3293_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2244_ _2161_/B _3183_/Q _2441_/A VGND VGND VPWR VPWR _2244_/X sky130_fd_sc_hd__a21bo_1
X_2175_ _2188_/B _3175_/Q _2389_/A _2044_/X VGND VGND VPWR VPWR _2175_/X sky130_fd_sc_hd__a31o_1
XFILLER_53_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1959_ _2740_/A _2313_/C _2612_/D _2492_/C VGND VGND VPWR VPWR _1959_/Y sky130_fd_sc_hd__a211oi_2
XFILLER_29_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_45 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_14_i_clk _3228_/CLK VGND VGND VPWR VPWR _3366_/CLK sky130_fd_sc_hd__clkbuf_16
XPHY_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2931_ _2928_/X _2826_/X _3100_/A _2930_/X VGND VGND VPWR VPWR _2931_/X sky130_fd_sc_hd__a211o_1
XFILLER_15_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2862_ _3343_/Q _1899_/X _3331_/D VGND VGND VPWR VPWR _3343_/D sky130_fd_sc_hd__mux2_1
XFILLER_30_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2793_ _3356_/Q _2888_/S _2801_/C VGND VGND VPWR VPWR _2793_/X sky130_fd_sc_hd__and3_1
Xclkbuf_leaf_29_i_clk clkbuf_leaf_1_i_clk/A VGND VGND VPWR VPWR _3407_/CLK sky130_fd_sc_hd__clkbuf_16
X_1813_ _1810_/Y _1812_/Y input8/X VGND VGND VPWR VPWR _1813_/Y sky130_fd_sc_hd__a21oi_1
X_1744_ input22/X _2020_/B _1739_/X _2023_/A VGND VGND VPWR VPWR _1762_/A sky130_fd_sc_hd__o31ai_1
X_1675_ _2585_/A _2368_/B VGND VGND VPWR VPWR _2463_/C sky130_fd_sc_hd__or2_2
X_3345_ _3345_/CLK _3345_/D VGND VGND VPWR VPWR _3345_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3276_ _3287_/CLK _3276_/D VGND VGND VPWR VPWR _3276_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2227_ _2520_/C _3230_/Q _1644_/X _2226_/X VGND VGND VPWR VPWR _2227_/X sky130_fd_sc_hd__a31o_1
XTAP_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2158_ _2389_/C input17/X _2157_/X _1608_/X VGND VGND VPWR VPWR _2158_/X sky130_fd_sc_hd__o211a_1
XFILLER_53_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2089_ _2436_/C _2448_/A _2520_/A VGND VGND VPWR VPWR _2090_/A sky130_fd_sc_hd__and3_1
XFILLER_53_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3130_ _3404_/CLK _3130_/D VGND VGND VPWR VPWR _3130_/Q sky130_fd_sc_hd__dfxtp_1
X_3061_ _3167_/Q _3195_/Q VGND VGND VPWR VPWR _3061_/X sky130_fd_sc_hd__or2_1
XFILLER_75_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2012_ _1808_/B _2012_/B _2012_/C VGND VGND VPWR VPWR _2013_/D sky130_fd_sc_hd__nand3b_1
X_2914_ _3370_/Q _2906_/X _2913_/X VGND VGND VPWR VPWR _3370_/D sky130_fd_sc_hd__a21o_1
X_2845_ _3093_/A _3322_/Q _2895_/A _2827_/X _3168_/Q VGND VGND VPWR VPWR _2845_/X
+ sky130_fd_sc_hd__a32o_1
XFILLER_12_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2776_ _3341_/Q _2768_/X _2740_/C _3308_/Q _2747_/X VGND VGND VPWR VPWR _3308_/D
+ sky130_fd_sc_hd__a32o_1
X_1727_ _3234_/Q VGND VGND VPWR VPWR _1727_/Y sky130_fd_sc_hd__inv_2
X_1658_ _3253_/Q _3254_/Q VGND VGND VPWR VPWR _1659_/A sky130_fd_sc_hd__or2b_1
X_3328_ _3404_/CLK _3328_/D VGND VGND VPWR VPWR _3328_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1589_ _1831_/A VGND VGND VPWR VPWR _2448_/A sky130_fd_sc_hd__buf_12
XFILLER_58_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3259_ _3404_/CLK _3259_/D VGND VGND VPWR VPWR _3259_/Q sky130_fd_sc_hd__dfxtp_2
XFILLER_37_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_80 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2630_ _2740_/A _2630_/B _2740_/B _2740_/C VGND VGND VPWR VPWR _2630_/X sky130_fd_sc_hd__or4_1
X_2561_ _1730_/B _3234_/Q _2574_/S VGND VGND VPWR VPWR _3234_/D sky130_fd_sc_hd__mux2_1
X_2492_ _2492_/A _2492_/B _2492_/C _2492_/D VGND VGND VPWR VPWR _2499_/A sky130_fd_sc_hd__nor4_2
XFILLER_4_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3113_ _3093_/A _3406_/Q _2895_/A _2825_/B VGND VGND VPWR VPWR _3113_/X sky130_fd_sc_hd__o22a_1
XFILLER_82_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3044_ _2832_/A _3189_/Q _3043_/X _2816_/X VGND VGND VPWR VPWR _3044_/X sky130_fd_sc_hd__o211a_1
XFILLER_48_380 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_199 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2828_ _2826_/X _3398_/Q _3093_/A _3198_/Q _2827_/X VGND VGND VPWR VPWR _2828_/Y
+ sky130_fd_sc_hd__a32oi_1
X_2759_ _3296_/Q _2888_/S _2758_/X VGND VGND VPWR VPWR _3296_/D sky130_fd_sc_hd__o21a_1
XFILLER_58_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_122 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1992_ _3334_/Q _2459_/A _1873_/B _2492_/A VGND VGND VPWR VPWR _1992_/X sky130_fd_sc_hd__o211a_1
XFILLER_60_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2613_ _2613_/A _2613_/B _2613_/C _2499_/A VGND VGND VPWR VPWR _2637_/A sky130_fd_sc_hd__or4b_1
X_2544_ _2520_/C _2520_/A _2520_/B _2543_/X _3227_/Q VGND VGND VPWR VPWR _3227_/D
+ sky130_fd_sc_hd__a32o_1
X_2475_ _3209_/Q _2476_/S _2301_/X VGND VGND VPWR VPWR _3209_/D sky130_fd_sc_hd__a21o_1
XFILLER_68_453 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3027_ _3024_/X _2826_/X _3100_/A _3026_/X VGND VGND VPWR VPWR _3027_/X sky130_fd_sc_hd__a211o_1
XFILLER_36_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_320 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2260_ _2594_/B _3256_/Q _2492_/C _2576_/B _3212_/Q VGND VGND VPWR VPWR _2260_/X
+ sky130_fd_sc_hd__a32o_1
XFILLER_34_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2191_ _2001_/X _2187_/X _2190_/X _3234_/Q VGND VGND VPWR VPWR _2191_/X sky130_fd_sc_hd__a22o_1
XFILLER_1_42 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_437 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1975_ _2520_/B _1661_/A _1974_/X _2494_/A VGND VGND VPWR VPWR _1977_/C sky130_fd_sc_hd__a211o_1
XFILLER_20_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2527_ _2692_/A _2527_/B _2533_/D VGND VGND VPWR VPWR _3220_/D sky130_fd_sc_hd__or3b_1
X_2458_ _2496_/B _2458_/B _2496_/C _2423_/X VGND VGND VPWR VPWR _2458_/X sky130_fd_sc_hd__or4b_1
X_2389_ _2389_/A _3197_/Q _2389_/C _2733_/A VGND VGND VPWR VPWR _2389_/X sky130_fd_sc_hd__and4_1
XFILLER_56_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1760_ _1756_/X _1757_/Y _1759_/Y VGND VGND VPWR VPWR _2018_/A sky130_fd_sc_hd__o21ai_1
X_1691_ _1691_/A VGND VGND VPWR VPWR _2612_/D sky130_fd_sc_hd__clkbuf_4
X_3361_ _3363_/CLK _3361_/D VGND VGND VPWR VPWR _3361_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2312_ _2312_/A VGND VGND VPWR VPWR _2312_/X sky130_fd_sc_hd__clkbuf_4
XFILLER_32_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3292_ _3350_/CLK _3292_/D VGND VGND VPWR VPWR _3292_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2243_ _2520_/C _3232_/Q _1644_/X _2242_/X VGND VGND VPWR VPWR _2247_/A sky130_fd_sc_hd__a31o_1
X_2174_ _2520_/B _1854_/Y _2172_/X _2173_/X VGND VGND VPWR VPWR _2174_/X sky130_fd_sc_hd__a22o_1
XFILLER_65_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_323 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1958_ _2726_/A _2424_/A _2434_/B _2436_/C VGND VGND VPWR VPWR _2051_/B sky130_fd_sc_hd__and4_1
X_1889_ _3136_/Q _3133_/Q _2884_/S VGND VGND VPWR VPWR _1889_/X sky130_fd_sc_hd__mux2_1
XFILLER_0_238 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2930_ _2832_/A _3170_/Q _2929_/X _2816_/X VGND VGND VPWR VPWR _2930_/X sky130_fd_sc_hd__o211a_1
X_2861_ _3342_/Q _1897_/X _3331_/D VGND VGND VPWR VPWR _3342_/D sky130_fd_sc_hd__mux2_1
XFILLER_30_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2792_ _3316_/Q _2747_/X _2791_/X VGND VGND VPWR VPWR _3316_/D sky130_fd_sc_hd__a21o_1
XFILLER_30_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1812_ _1815_/B _1815_/C _1809_/C _1709_/Y VGND VGND VPWR VPWR _1812_/Y sky130_fd_sc_hd__o31ai_1
X_1743_ input23/X _1743_/B _1743_/C VGND VGND VPWR VPWR _2023_/A sky130_fd_sc_hd__nand3b_1
XFILLER_7_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1674_ _3131_/Q _1599_/X _1624_/X _1673_/Y VGND VGND VPWR VPWR _3131_/D sky130_fd_sc_hd__o22a_1
X_3344_ _3345_/CLK _3344_/D VGND VGND VPWR VPWR _3344_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3275_ _3287_/CLK _3275_/D VGND VGND VPWR VPWR _3275_/Q sky130_fd_sc_hd__dfxtp_2
XTAP_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2226_ _3238_/Q _2207_/X _2225_/X _2209_/X VGND VGND VPWR VPWR _2226_/X sky130_fd_sc_hd__o211a_1
XTAP_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2157_ _2389_/A _3173_/Q _2441_/A VGND VGND VPWR VPWR _2157_/X sky130_fd_sc_hd__a21bo_1
X_2088_ _2161_/B VGND VGND VPWR VPWR _2389_/A sky130_fd_sc_hd__buf_8
XFILLER_13_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_407 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3060_ _3395_/Q _3392_/Q _3084_/S VGND VGND VPWR VPWR _3060_/X sky130_fd_sc_hd__mux2_1
X_2011_ _2012_/B _2012_/C _1808_/B VGND VGND VPWR VPWR _2013_/C sky130_fd_sc_hd__a21bo_1
XFILLER_50_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2913_ _3170_/Q _2907_/X _2909_/X _2912_/X VGND VGND VPWR VPWR _2913_/X sky130_fd_sc_hd__o211a_1
X_2844_ _2896_/C _2895_/A VGND VGND VPWR VPWR _2844_/X sky130_fd_sc_hd__or2_1
X_2775_ _3340_/Q _2768_/X _2740_/C _3307_/Q _2747_/X VGND VGND VPWR VPWR _3307_/D
+ sky130_fd_sc_hd__a32o_1
X_1726_ _3234_/Q _1740_/B _1740_/C _1726_/D VGND VGND VPWR VPWR _1729_/A sky130_fd_sc_hd__nand4_1
X_1657_ _1648_/Y _1653_/X _3331_/Q _1656_/X VGND VGND VPWR VPWR _1657_/X sky130_fd_sc_hd__o2bb2a_1
X_1588_ _3255_/Q VGND VGND VPWR VPWR _1831_/A sky130_fd_sc_hd__inv_2
X_3327_ _3407_/CLK _3327_/D VGND VGND VPWR VPWR _3327_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3258_ _3404_/CLK _3258_/D VGND VGND VPWR VPWR _3258_/Q sky130_fd_sc_hd__dfxtp_2
XTAP_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2209_ _2384_/C _2120_/B _2335_/A _2190_/D _2001_/X VGND VGND VPWR VPWR _2209_/X
+ sky130_fd_sc_hd__o32a_1
X_3189_ _3200_/CLK _3189_/D VGND VGND VPWR VPWR _3189_/Q sky130_fd_sc_hd__dfxtp_2
XFILLER_14_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_13_i_clk _3228_/CLK VGND VGND VPWR VPWR _3363_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_76_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_28_i_clk clkbuf_leaf_1_i_clk/A VGND VGND VPWR VPWR _3398_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_64_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_455 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2560_ _1749_/A _3233_/Q _2574_/S VGND VGND VPWR VPWR _3233_/D sky130_fd_sc_hd__mux2_1
X_2491_ _2482_/Y _2489_/X _2490_/Y VGND VGND VPWR VPWR _3211_/D sky130_fd_sc_hd__o21ai_1
XFILLER_4_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3112_ _3101_/S _3109_/Y _3111_/Y VGND VGND VPWR VPWR _3405_/D sky130_fd_sc_hd__o21ai_1
XFILLER_67_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3043_ _3055_/A _3192_/Q VGND VGND VPWR VPWR _3043_/X sky130_fd_sc_hd__or2_1
XFILLER_23_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2827_ _2851_/B _2827_/B _3055_/A _3165_/Q VGND VGND VPWR VPWR _2827_/X sky130_fd_sc_hd__and4b_1
X_2758_ _3353_/Q _2801_/C _2745_/X _3210_/Q _2747_/X VGND VGND VPWR VPWR _2758_/X
+ sky130_fd_sc_hd__a221o_1
X_1709_ _3240_/Q VGND VGND VPWR VPWR _1709_/Y sky130_fd_sc_hd__inv_2
X_2689_ _3123_/A _2688_/X _2104_/X _2066_/X VGND VGND VPWR VPWR _2689_/Y sky130_fd_sc_hd__o211ai_2
XTAP_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_465 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1991_ _2318_/A _2520_/A _2520_/B VGND VGND VPWR VPWR _2456_/B sky130_fd_sc_hd__and3_2
XFILLER_13_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_241 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2612_ _2611_/X _2612_/B _2612_/C _2612_/D VGND VGND VPWR VPWR _2641_/A sky130_fd_sc_hd__and4b_1
XFILLER_62_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2543_ _3226_/Q _3225_/Q _2543_/C _2543_/D VGND VGND VPWR VPWR _2543_/X sky130_fd_sc_hd__or4_1
X_2474_ _3208_/Q _2476_/S _2290_/X VGND VGND VPWR VPWR _3208_/D sky130_fd_sc_hd__a21o_1
XFILLER_68_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3026_ _2832_/A _3186_/Q _3025_/X _2816_/X VGND VGND VPWR VPWR _3026_/X sky130_fd_sc_hd__o211a_1
XFILLER_36_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_38 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_71 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2190_ _2520_/C _2411_/B _2577_/D _2190_/D VGND VGND VPWR VPWR _2190_/X sky130_fd_sc_hd__or4_2
XFILLER_49_91 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_173 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1974_ _2424_/A _2434_/B _2448_/B _2335_/A VGND VGND VPWR VPWR _1974_/X sky130_fd_sc_hd__and4b_1
Xclkbuf_2_2__f_i_clk clkbuf_0_i_clk/X VGND VGND VPWR VPWR clkbuf_2_2__f_i_clk/X sky130_fd_sc_hd__clkbuf_16
X_2526_ _3220_/Q _3219_/Q _3218_/Q _2626_/B VGND VGND VPWR VPWR _2533_/D sky130_fd_sc_hd__or4_2
X_2457_ _1873_/B _2492_/B _2552_/B _1992_/X VGND VGND VPWR VPWR _2496_/C sky130_fd_sc_hd__a211o_1
X_2388_ _2733_/A _2441_/A input5/X _2644_/D VGND VGND VPWR VPWR _2388_/X sky130_fd_sc_hd__and4bb_1
XFILLER_28_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3009_ _3006_/X _2826_/X _3100_/A _3008_/X VGND VGND VPWR VPWR _3009_/X sky130_fd_sc_hd__a211o_1
XFILLER_45_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1690_ _2043_/B _2740_/A _2492_/B VGND VGND VPWR VPWR _1691_/A sky130_fd_sc_hd__and3_1
X_3360_ _3363_/CLK _3360_/D VGND VGND VPWR VPWR _3360_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2311_ _2726_/A _2520_/A _2436_/C VGND VGND VPWR VPWR _2312_/A sky130_fd_sc_hd__and3_1
XTAP_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3291_ _3350_/CLK _3291_/D VGND VGND VPWR VPWR _3291_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2242_ _3240_/Q _2207_/X _2241_/X _2209_/X VGND VGND VPWR VPWR _2242_/X sky130_fd_sc_hd__o211a_1
X_2173_ _2318_/A _3262_/Q _1644_/X _2137_/X _3232_/Q VGND VGND VPWR VPWR _2173_/X
+ sky130_fd_sc_hd__a32o_1
XFILLER_38_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1957_ _2384_/C _2434_/B _2424_/A _2726_/A VGND VGND VPWR VPWR _2456_/D sky130_fd_sc_hd__and4_2
X_1888_ _3136_/Q _1887_/X _1932_/S VGND VGND VPWR VPWR _3136_/D sky130_fd_sc_hd__mux2_1
XFILLER_0_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2509_ _3337_/Q _2110_/C _2508_/X _2499_/X VGND VGND VPWR VPWR _2509_/X sky130_fd_sc_hd__a211o_1
XFILLER_56_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2860_ _3341_/Q _1895_/X _3331_/D VGND VGND VPWR VPWR _3341_/D sky130_fd_sc_hd__mux2_1
X_1811_ _3240_/Q _1809_/Y _1810_/Y input8/X VGND VGND VPWR VPWR _1811_/X sky130_fd_sc_hd__o211a_1
X_2791_ _3355_/Q _2888_/S _2801_/C VGND VGND VPWR VPWR _2791_/X sky130_fd_sc_hd__and3_1
X_1742_ _1815_/B _1815_/C _1778_/A VGND VGND VPWR VPWR _1743_/C sky130_fd_sc_hd__o21ai_1
X_1673_ _1626_/X _1670_/Y _1672_/X VGND VGND VPWR VPWR _1673_/Y sky130_fd_sc_hd__a21oi_1
XTAP_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3343_ _3343_/CLK _3343_/D VGND VGND VPWR VPWR _3343_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3274_ _3287_/CLK _3274_/D VGND VGND VPWR VPWR _3274_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2225_ _3268_/Q _2552_/A _2576_/B _3260_/Q _2137_/X VGND VGND VPWR VPWR _2225_/X
+ sky130_fd_sc_hd__a221o_1
XTAP_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2156_ _2188_/B _3173_/Q _2389_/A _2044_/X VGND VGND VPWR VPWR _2156_/X sky130_fd_sc_hd__a31o_1
XFILLER_26_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_202 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2087_ _2087_/A VGND VGND VPWR VPWR _2161_/B sky130_fd_sc_hd__buf_4
XFILLER_53_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2989_ _3055_/A _3183_/Q VGND VGND VPWR VPWR _2989_/X sky130_fd_sc_hd__or2_1
XFILLER_21_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_298 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_430 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2010_ input8/X _2007_/Y _2009_/X VGND VGND VPWR VPWR _2013_/A sky130_fd_sc_hd__a21oi_1
XFILLER_50_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2912_ _3169_/Q _2910_/X _2911_/X _3401_/Q _2922_/A VGND VGND VPWR VPWR _2912_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_50_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2843_ _2839_/X _3328_/Q _2843_/S VGND VGND VPWR VPWR _3328_/D sky130_fd_sc_hd__mux2_1
X_2774_ _3339_/Q _2768_/X _2740_/C _3306_/Q _2747_/X VGND VGND VPWR VPWR _3306_/D
+ sky130_fd_sc_hd__a32o_1
X_1725_ _3232_/Q _3233_/Q VGND VGND VPWR VPWR _1726_/D sky130_fd_sc_hd__and2_1
X_1656_ _1656_/A VGND VGND VPWR VPWR _1656_/X sky130_fd_sc_hd__buf_4
X_1587_ _3226_/Q _3218_/Q _3227_/Q VGND VGND VPWR VPWR _3130_/D sky130_fd_sc_hd__or3b_1
X_3326_ _3407_/CLK _3326_/D VGND VGND VPWR VPWR _3326_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3257_ _3404_/CLK _3257_/D VGND VGND VPWR VPWR _3257_/Q sky130_fd_sc_hd__dfxtp_2
XFILLER_37_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_9_i_clk _3228_/CLK VGND VGND VPWR VPWR _3203_/CLK sky130_fd_sc_hd__clkbuf_16
X_2208_ _3266_/Q _2552_/A _2576_/B _3258_/Q _2137_/X VGND VGND VPWR VPWR _2208_/X
+ sky130_fd_sc_hd__a221o_1
X_3188_ _3240_/CLK _3188_/D VGND VGND VPWR VPWR _3188_/Q sky130_fd_sc_hd__dfxtp_2
XFILLER_81_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2139_ _2520_/B _1854_/Y _2136_/X _2138_/X VGND VGND VPWR VPWR _2139_/X sky130_fd_sc_hd__a22o_1
XFILLER_81_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_72 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_467 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_282 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2490_ _2114_/D _2434_/X _3211_/Q VGND VGND VPWR VPWR _2490_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_4_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3111_ _3110_/X _3101_/S _3405_/Q VGND VGND VPWR VPWR _3111_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_67_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3042_ _3392_/Q _3389_/Q _3084_/S VGND VGND VPWR VPWR _3042_/X sky130_fd_sc_hd__mux2_1
XFILLER_63_341 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2826_ _2826_/A VGND VGND VPWR VPWR _2826_/X sky130_fd_sc_hd__buf_8
X_2757_ _3295_/Q _2888_/S _2756_/X VGND VGND VPWR VPWR _3295_/D sky130_fd_sc_hd__o21a_1
X_2688_ _2668_/C _2687_/X _2658_/B _2001_/X VGND VGND VPWR VPWR _2688_/X sky130_fd_sc_hd__o2bb2a_1
X_1708_ _1701_/X _1707_/Y input9/X VGND VGND VPWR VPWR _1708_/Y sky130_fd_sc_hd__a21oi_1
X_1639_ _2188_/A _1630_/Y _2613_/A _2494_/B _1638_/X VGND VGND VPWR VPWR _1639_/X
+ sky130_fd_sc_hd__o2111a_1
XTAP_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3309_ _3343_/CLK _3309_/D VGND VGND VPWR VPWR _3309_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_385 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1990_ _2616_/C _1873_/B _1608_/X _1986_/Y _1989_/X VGND VGND VPWR VPWR _1990_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_60_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2611_ _2644_/D _2733_/A _3131_/Q VGND VGND VPWR VPWR _2611_/X sky130_fd_sc_hd__o21ba_1
X_2542_ _2540_/Y _2535_/Y _2541_/X _2692_/A VGND VGND VPWR VPWR _3226_/D sky130_fd_sc_hd__a211o_1
X_2473_ _3272_/Q _3207_/Q _2476_/S VGND VGND VPWR VPWR _3207_/D sky130_fd_sc_hd__mux2_1
XFILLER_68_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3025_ _3055_/A _3189_/Q VGND VGND VPWR VPWR _3025_/X sky130_fd_sc_hd__or2_1
XFILLER_34_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_12_i_clk _3228_/CLK VGND VGND VPWR VPWR _3356_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_34_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2809_ _2889_/B _2819_/C _2808_/Y VGND VGND VPWR VPWR _2851_/C sky130_fd_sc_hd__a21oi_2
Xclkbuf_leaf_27_i_clk clkbuf_leaf_1_i_clk/A VGND VGND VPWR VPWR _3289_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_59_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1973_ _2434_/B _2384_/B _2616_/D VGND VGND VPWR VPWR _3122_/B sky130_fd_sc_hd__and3_2
XFILLER_60_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2525_ _3219_/Q _3218_/Q _2626_/B _3220_/Q VGND VGND VPWR VPWR _2527_/B sky130_fd_sc_hd__o31a_1
X_2456_ _2575_/S _2456_/B _2552_/A _2456_/D VGND VGND VPWR VPWR _2458_/B sky130_fd_sc_hd__or4_1
X_2387_ _1772_/B _2494_/A _2335_/C _2386_/X VGND VGND VPWR VPWR _2387_/X sky130_fd_sc_hd__a31o_1
XFILLER_68_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3008_ _2832_/A _3183_/Q _3007_/X _2816_/X VGND VGND VPWR VPWR _3008_/X sky130_fd_sc_hd__o211a_1
XFILLER_43_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3290_ _3404_/CLK _3290_/D VGND VGND VPWR VPWR _3290_/Q sky130_fd_sc_hd__dfxtp_1
X_2310_ _3189_/Q _2129_/X _2306_/X _2309_/X VGND VGND VPWR VPWR _3189_/D sky130_fd_sc_hd__o22a_1
XTAP_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2241_ _3270_/Q _2552_/A _2576_/B _3262_/Q _2137_/X VGND VGND VPWR VPWR _2241_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_18_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2172_ _3232_/Q _2337_/C _2135_/X _2001_/X VGND VGND VPWR VPWR _2172_/X sky130_fd_sc_hd__a31o_1
XFILLER_65_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1956_ _2448_/B _1956_/B _2434_/B VGND VGND VPWR VPWR _1956_/X sky130_fd_sc_hd__or3b_1
X_1887_ _3135_/Q input4/X _2884_/S VGND VGND VPWR VPWR _1887_/X sky130_fd_sc_hd__mux2_1
XFILLER_0_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2508_ _2520_/C _2411_/B _2102_/D _3259_/Q _1656_/X VGND VGND VPWR VPWR _2508_/X
+ sky130_fd_sc_hd__o311a_1
X_2439_ _1679_/B _2430_/A _1740_/B _2146_/X _2494_/B VGND VGND VPWR VPWR _2439_/X
+ sky130_fd_sc_hd__o221a_1
XFILLER_29_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_269 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1810_ _3240_/Q _1810_/B _1810_/C _2020_/D VGND VGND VPWR VPWR _1810_/Y sky130_fd_sc_hd__nand4_2
X_2790_ _3315_/Q _2747_/X _2789_/X VGND VGND VPWR VPWR _3315_/D sky130_fd_sc_hd__a21o_1
XFILLER_7_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1741_ _3236_/Q VGND VGND VPWR VPWR _1778_/A sky130_fd_sc_hd__inv_2
X_1672_ _2114_/C _3122_/A _2740_/A VGND VGND VPWR VPWR _1672_/X sky130_fd_sc_hd__and3_1
X_3342_ _3343_/CLK _3342_/D VGND VGND VPWR VPWR _3342_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3273_ _3278_/CLK _3273_/D VGND VGND VPWR VPWR _3273_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2224_ _3180_/Q _2129_/X _2220_/X _2223_/X VGND VGND VPWR VPWR _3180_/D sky130_fd_sc_hd__o22a_1
XTAP_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2155_ _2520_/B _1854_/Y _2153_/X _2154_/X VGND VGND VPWR VPWR _2155_/X sky130_fd_sc_hd__a22o_1
XFILLER_26_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2086_ _3203_/Q _2086_/B VGND VGND VPWR VPWR _2087_/A sky130_fd_sc_hd__or2_1
XFILLER_53_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2988_ _3383_/Q _3380_/Q _3093_/A VGND VGND VPWR VPWR _2988_/X sky130_fd_sc_hd__mux2_1
X_1939_ _3161_/Q _3158_/Q _3330_/Q VGND VGND VPWR VPWR _1939_/X sky130_fd_sc_hd__mux2_1
XFILLER_67_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2911_ _2895_/A _2825_/B _2831_/Y VGND VGND VPWR VPWR _2911_/X sky130_fd_sc_hd__o21a_1
X_2842_ _2895_/A _2840_/X _2841_/X VGND VGND VPWR VPWR _2843_/S sky130_fd_sc_hd__o21ai_1
X_2773_ _3338_/Q _2768_/X _2740_/C _3305_/Q _2747_/X VGND VGND VPWR VPWR _3305_/D
+ sky130_fd_sc_hd__a32o_1
X_1724_ _3230_/Q _3231_/Q VGND VGND VPWR VPWR _1740_/C sky130_fd_sc_hd__and2_1
X_1655_ _2726_/A _2726_/C _2448_/B _2594_/B VGND VGND VPWR VPWR _1656_/A sky130_fd_sc_hd__or4_1
X_1586_ _3250_/Q _3327_/Q VGND VGND VPWR VPWR _1586_/X sky130_fd_sc_hd__and2b_1
X_3325_ _3407_/CLK _3325_/D VGND VGND VPWR VPWR _3325_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3256_ _3404_/CLK _3256_/D VGND VGND VPWR VPWR _3256_/Q sky130_fd_sc_hd__dfxtp_2
XTAP_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2207_ _2520_/C _2411_/B _2577_/D _2187_/X VGND VGND VPWR VPWR _2207_/X sky130_fd_sc_hd__o31a_1
XTAP_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3187_ _3240_/CLK _3187_/D VGND VGND VPWR VPWR _3187_/Q sky130_fd_sc_hd__dfxtp_2
XFILLER_66_372 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2138_ _2318_/A _3258_/Q _1644_/X _2137_/X _2585_/A VGND VGND VPWR VPWR _2138_/X
+ sky130_fd_sc_hd__a32o_1
X_2069_ _2424_/A _2520_/B _2547_/A _2068_/X VGND VGND VPWR VPWR _2070_/D sky130_fd_sc_hd__a31o_1
XFILLER_22_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_435 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_294 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_479 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3110_ _3403_/Q _3404_/Q _3097_/B _3108_/D VGND VGND VPWR VPWR _3110_/X sky130_fd_sc_hd__o31a_1
XFILLER_68_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3041_ _3392_/Q _2906_/X _3040_/X VGND VGND VPWR VPWR _3392_/D sky130_fd_sc_hd__a21o_1
XFILLER_67_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_353 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2825_ _2895_/A _2825_/B VGND VGND VPWR VPWR _2826_/A sky130_fd_sc_hd__or2_1
X_2756_ _3352_/Q _2801_/C _2745_/X _3209_/Q _2747_/X VGND VGND VPWR VPWR _2756_/X
+ sky130_fd_sc_hd__a221o_1
X_2687_ _1692_/Y _2612_/C _2668_/B _2653_/X VGND VGND VPWR VPWR _2687_/X sky130_fd_sc_hd__o211a_1
X_1707_ _1810_/B _1810_/C _1715_/C _2020_/D VGND VGND VPWR VPWR _1707_/Y sky130_fd_sc_hd__nand4_1
X_1638_ _2086_/B _2188_/A _1679_/B VGND VGND VPWR VPWR _1638_/X sky130_fd_sc_hd__a21o_1
X_1569_ _2889_/B _2896_/C _2837_/A _3367_/Q VGND VGND VPWR VPWR _1570_/A sky130_fd_sc_hd__and4b_1
XTAP_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3308_ _3343_/CLK _3308_/D VGND VGND VPWR VPWR _3308_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_147 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3239_ _3240_/CLK _3239_/D VGND VGND VPWR VPWR _3239_/Q sky130_fd_sc_hd__dfxtp_2
XFILLER_54_320 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_128 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_287 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2610_ _2607_/X _2608_/Y _2091_/C _2609_/Y VGND VGND VPWR VPWR _2639_/A sky130_fd_sc_hd__a31o_1
Xclkbuf_leaf_8_i_clk _3288_/CLK VGND VGND VPWR VPWR _3208_/CLK sky130_fd_sc_hd__clkbuf_16
X_2541_ _3225_/Q _2543_/C _2543_/D _3226_/Q VGND VGND VPWR VPWR _2541_/X sky130_fd_sc_hd__o31a_1
X_2472_ _3271_/Q _3206_/Q _2476_/S VGND VGND VPWR VPWR _3206_/D sky130_fd_sc_hd__mux2_1
XFILLER_48_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3024_ _3389_/Q _3386_/Q _3093_/A VGND VGND VPWR VPWR _3024_/X sky130_fd_sc_hd__mux2_1
X_2808_ _2889_/B _2889_/A VGND VGND VPWR VPWR _2808_/Y sky130_fd_sc_hd__nor2_1
X_2739_ _2739_/A _3203_/Q _2739_/C _2644_/D VGND VGND VPWR VPWR _2739_/X sky130_fd_sc_hd__or4b_1
XFILLER_75_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1972_ _2740_/A _2384_/B _1994_/B VGND VGND VPWR VPWR _1977_/A sky130_fd_sc_hd__and3_2
XFILLER_60_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2524_ _2522_/Y _2523_/X _2692_/A VGND VGND VPWR VPWR _3219_/D sky130_fd_sc_hd__a21oi_1
X_2455_ _2552_/C _2594_/B _1977_/A _1955_/C _2312_/X VGND VGND VPWR VPWR _2496_/B
+ sky130_fd_sc_hd__a2111o_1
X_2386_ _2378_/X _2385_/X _2594_/B _2740_/C VGND VGND VPWR VPWR _2386_/X sky130_fd_sc_hd__o2bb2a_1
XFILLER_68_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_106 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3007_ _3055_/A _3186_/Q VGND VGND VPWR VPWR _3007_/X sky130_fd_sc_hd__or2_1
XFILLER_47_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_84 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_11_i_clk _3228_/CLK VGND VGND VPWR VPWR _3353_/CLK sky130_fd_sc_hd__clkbuf_16
XTAP_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2240_ _3182_/Q _2129_/X _2236_/X _2239_/X VGND VGND VPWR VPWR _3182_/D sky130_fd_sc_hd__o22a_1
X_2171_ _2170_/X _3174_/Q _2247_/D VGND VGND VPWR VPWR _3174_/D sky130_fd_sc_hd__mux2_1
XFILLER_38_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_26_i_clk clkbuf_2_2__f_i_clk/X VGND VGND VPWR VPWR _3194_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_38_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1955_ _1955_/A _1960_/A _1955_/C _2551_/D VGND VGND VPWR VPWR _2581_/A sky130_fd_sc_hd__or4b_4
X_1886_ _3135_/Q _1885_/X _1932_/S VGND VGND VPWR VPWR _3135_/D sky130_fd_sc_hd__mux2_1
XFILLER_0_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2507_ _3214_/Q _2497_/Y _2506_/X _2078_/X VGND VGND VPWR VPWR _3214_/D sky130_fd_sc_hd__o211a_1
X_2438_ _2335_/A _1661_/A _2419_/B VGND VGND VPWR VPWR _2451_/C sky130_fd_sc_hd__a21oi_1
X_2369_ _2188_/B _3196_/Q _2161_/B _2120_/B _2368_/X VGND VGND VPWR VPWR _2369_/X
+ sky130_fd_sc_hd__a311o_1
XFILLER_29_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_20 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1740_ _3236_/Q _1740_/B _1740_/C _1810_/C VGND VGND VPWR VPWR _1743_/B sky130_fd_sc_hd__nand4_1
XFILLER_7_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_66 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1671_ _2740_/B _2739_/A _2739_/C _2644_/D VGND VGND VPWR VPWR _2114_/C sky130_fd_sc_hd__or4b_1
XFILLER_7_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3341_ _3343_/CLK _3341_/D VGND VGND VPWR VPWR _3341_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3272_ _3278_/CLK _3272_/D VGND VGND VPWR VPWR _3272_/Q sky130_fd_sc_hd__dfxtp_2
XTAP_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2223_ _2733_/A _2090_/X _2222_/X _2247_/D VGND VGND VPWR VPWR _2223_/X sky130_fd_sc_hd__a31o_1
XTAP_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2154_ _2318_/A _3260_/Q _1644_/X _2137_/X _3230_/Q VGND VGND VPWR VPWR _2154_/X
+ sky130_fd_sc_hd__a32o_1
XFILLER_38_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2085_ _3168_/Q _2080_/Y _2084_/X _2078_/X VGND VGND VPWR VPWR _3168_/D sky130_fd_sc_hd__o211a_1
XFILLER_53_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2987_ _3383_/Q _2906_/X _2986_/X VGND VGND VPWR VPWR _3383_/D sky130_fd_sc_hd__a21o_1
X_1938_ _3161_/Q _1937_/X _1942_/S VGND VGND VPWR VPWR _3161_/D sky130_fd_sc_hd__mux2_1
X_1869_ _3203_/Q VGND VGND VPWR VPWR _2097_/A sky130_fd_sc_hd__inv_2
XFILLER_12_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_451 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2910_ _2837_/A _2889_/B _2813_/C _2671_/A _2841_/X VGND VGND VPWR VPWR _2910_/X
+ sky130_fd_sc_hd__o311a_1
XFILLER_43_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2841_ _3367_/Q _2889_/B _2837_/A VGND VGND VPWR VPWR _2841_/X sky130_fd_sc_hd__or3b_2
XFILLER_31_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2772_ _3337_/Q _2768_/X _2740_/C _3304_/Q _2747_/X VGND VGND VPWR VPWR _3304_/D
+ sky130_fd_sc_hd__a32o_1
X_1723_ _1723_/A VGND VGND VPWR VPWR _1740_/B sky130_fd_sc_hd__clkbuf_4
X_1654_ _3254_/Q _3253_/Q VGND VGND VPWR VPWR _2726_/C sky130_fd_sc_hd__nand2_8
X_1585_ _3250_/Q _3326_/Q VGND VGND VPWR VPWR _1585_/X sky130_fd_sc_hd__and2b_1
X_3324_ _3407_/CLK _3324_/D VGND VGND VPWR VPWR _3324_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3255_ _3255_/CLK _3255_/D VGND VGND VPWR VPWR _3255_/Q sky130_fd_sc_hd__dfxtp_4
X_2206_ _3178_/Q _2129_/X _2205_/X VGND VGND VPWR VPWR _3178_/D sky130_fd_sc_hd__o21a_1
XTAP_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3186_ _3200_/CLK _3186_/D VGND VGND VPWR VPWR _3186_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_66_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_310 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2137_ _2318_/A _2520_/A _2436_/C _2552_/C VGND VGND VPWR VPWR _2137_/X sky130_fd_sc_hd__a31o_4
XFILLER_66_384 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2068_ _2612_/D _2576_/B _2068_/C _2112_/B VGND VGND VPWR VPWR _2068_/X sky130_fd_sc_hd__or4b_1
XFILLER_41_207 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_376 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_262 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3040_ _3192_/Q _2907_/X _2909_/X _3039_/X VGND VGND VPWR VPWR _3040_/X sky130_fd_sc_hd__o211a_1
XFILLER_48_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2824_ _2817_/X _2821_/X _3324_/Q _2829_/A VGND VGND VPWR VPWR _3324_/D sky130_fd_sc_hd__o22a_1
X_2755_ _3294_/Q _2888_/S _2754_/X VGND VGND VPWR VPWR _3294_/D sky130_fd_sc_hd__o21a_1
X_2686_ _2384_/C _2335_/A _2492_/A _1955_/A VGND VGND VPWR VPWR _3123_/A sky130_fd_sc_hd__a31o_1
X_1706_ _3240_/Q _3241_/Q VGND VGND VPWR VPWR _1715_/C sky130_fd_sc_hd__and2_1
X_1637_ _3289_/Q VGND VGND VPWR VPWR _1679_/B sky130_fd_sc_hd__buf_8
X_3307_ _3343_/CLK _3307_/D VGND VGND VPWR VPWR _3307_/Q sky130_fd_sc_hd__dfxtp_1
X_1568_ _2837_/A _3367_/Q VGND VGND VPWR VPWR _2819_/C sky130_fd_sc_hd__nor2_1
XTAP_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_104 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3238_ _3238_/CLK _3238_/D VGND VGND VPWR VPWR _3238_/Q sky130_fd_sc_hd__dfxtp_2
XFILLER_58_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3169_ _3398_/CLK _3169_/D VGND VGND VPWR VPWR _3169_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_54_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_310 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2540_ _3226_/Q _3225_/Q VGND VGND VPWR VPWR _2540_/Y sky130_fd_sc_hd__nor2_1
XFILLER_5_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2471_ _3270_/Q _3205_/Q _2476_/S VGND VGND VPWR VPWR _3205_/D sky130_fd_sc_hd__mux2_1
X_3023_ _3389_/Q _2906_/X _3022_/X VGND VGND VPWR VPWR _3389_/D sky130_fd_sc_hd__a21o_1
XFILLER_36_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2807_ _2837_/A _3367_/Q VGND VGND VPWR VPWR _2889_/A sky130_fd_sc_hd__nand2_1
X_2738_ _1608_/X _2738_/B _2738_/C _2738_/D VGND VGND VPWR VPWR _2738_/X sky130_fd_sc_hd__and4b_1
X_2669_ _2312_/X _2665_/X _2668_/X VGND VGND VPWR VPWR _2669_/Y sky130_fd_sc_hd__a21oi_1
XFILLER_27_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1971_ _2448_/A _2726_/C _2102_/D _2476_/S VGND VGND VPWR VPWR _1978_/B sky130_fd_sc_hd__o31a_1
XFILLER_60_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2523_ _3219_/Q _3218_/Q _2626_/B VGND VGND VPWR VPWR _2523_/X sky130_fd_sc_hd__or3_1
X_2454_ _2453_/X _3202_/Q _2454_/S VGND VGND VPWR VPWR _3202_/D sky130_fd_sc_hd__mux2_1
X_2385_ _3197_/Q _2162_/X _2383_/Y _2657_/A VGND VGND VPWR VPWR _2385_/X sky130_fd_sc_hd__o2bb2a_1
XFILLER_28_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput1 i_qspi_dat[0] VGND VGND VPWR VPWR input1/X sky130_fd_sc_hd__clkbuf_1
XFILLER_49_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3006_ _3386_/Q _3383_/Q _3093_/A VGND VGND VPWR VPWR _3006_/X sky130_fd_sc_hd__mux2_1
XFILLER_64_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_210 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_7_i_clk _3288_/CLK VGND VGND VPWR VPWR _3350_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_15_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2170_ _3174_/Q _2162_/X _2164_/X _2166_/X _2169_/X VGND VGND VPWR VPWR _2170_/X
+ sky130_fd_sc_hd__a2111o_1
XFILLER_53_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_154 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1954_ _2120_/B _2102_/D _1964_/C _2743_/C VGND VGND VPWR VPWR _2551_/D sky130_fd_sc_hd__o211a_1
X_1885_ _3134_/Q input3/X _2884_/S VGND VGND VPWR VPWR _1885_/X sky130_fd_sc_hd__mux2_1
X_2506_ _3336_/Q _2110_/C _2505_/X _2499_/X VGND VGND VPWR VPWR _2506_/X sky130_fd_sc_hd__a211o_1
X_2437_ _2312_/X _2433_/X _2435_/X _2436_/X VGND VGND VPWR VPWR _2437_/X sky130_fd_sc_hd__a211o_1
X_2368_ _2585_/A _2368_/B _2368_/C VGND VGND VPWR VPWR _2368_/X sky130_fd_sc_hd__and3_1
XFILLER_56_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2299_ _2733_/A _2090_/X _2298_/X _2247_/D VGND VGND VPWR VPWR _2299_/X sky130_fd_sc_hd__a31o_1
XFILLER_44_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_246 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_34 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1670_ _3288_/Q _1639_/X _1669_/X VGND VGND VPWR VPWR _1670_/Y sky130_fd_sc_hd__a21oi_1
X_3340_ _3343_/CLK _3340_/D VGND VGND VPWR VPWR _3340_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3271_ _3278_/CLK _3271_/D VGND VGND VPWR VPWR _3271_/Q sky130_fd_sc_hd__dfxtp_2
XTAP_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2222_ _2389_/C _1821_/B _2221_/X VGND VGND VPWR VPWR _2222_/X sky130_fd_sc_hd__o21a_1
XTAP_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2153_ _3230_/Q _2337_/C _2135_/X _2001_/X VGND VGND VPWR VPWR _2153_/X sky130_fd_sc_hd__a31o_1
XFILLER_19_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2084_ _1978_/B _2081_/X _2083_/X _2076_/D VGND VGND VPWR VPWR _2084_/X sky130_fd_sc_hd__a31o_1
XFILLER_46_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2986_ _3183_/Q _2907_/X _2909_/X _2985_/X VGND VGND VPWR VPWR _2986_/X sky130_fd_sc_hd__o211a_1
X_1937_ _3160_/Q _3157_/Q _3330_/Q VGND VGND VPWR VPWR _1937_/X sky130_fd_sc_hd__mux2_1
X_1868_ _2441_/A _1611_/Y _2644_/D VGND VGND VPWR VPWR _1871_/A sky130_fd_sc_hd__o21a_1
X_1799_ _1789_/Y _1791_/Y _1795_/Y _1798_/Y VGND VGND VPWR VPWR _1799_/Y sky130_fd_sc_hd__a22oi_1
XFILLER_69_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_290 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_10_i_clk _3228_/CLK VGND VGND VPWR VPWR _3255_/CLK sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_25_i_clk clkbuf_2_2__f_i_clk/X VGND VGND VPWR VPWR _3397_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_4_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_319 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_463 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2840_ _2837_/A _2813_/C _2896_/C VGND VGND VPWR VPWR _2840_/X sky130_fd_sc_hd__o21a_1
XFILLER_31_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2771_ _3336_/Q _2768_/X _2740_/C _3303_/Q _2747_/X VGND VGND VPWR VPWR _3303_/D
+ sky130_fd_sc_hd__a32o_1
X_1722_ _2585_/A _2368_/B VGND VGND VPWR VPWR _1723_/A sky130_fd_sc_hd__and2_1
X_1653_ _1653_/A _2004_/B _2436_/A _2577_/D VGND VGND VPWR VPWR _1653_/X sky130_fd_sc_hd__or4_1
X_1584_ _3250_/Q _3325_/Q VGND VGND VPWR VPWR _1584_/X sky130_fd_sc_hd__and2b_1
XTAP_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3323_ _3398_/CLK _3323_/D VGND VGND VPWR VPWR _3323_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3254_ _3255_/CLK _3254_/D VGND VGND VPWR VPWR _3254_/Q sky130_fd_sc_hd__dfxtp_4
X_2205_ _1872_/B _2201_/X _2202_/X _2204_/X _2247_/D VGND VGND VPWR VPWR _2205_/X
+ sky130_fd_sc_hd__a311o_1
XTAP_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3185_ _3200_/CLK _3185_/D VGND VGND VPWR VPWR _3185_/Q sky130_fd_sc_hd__dfxtp_1
X_2136_ _2585_/A _2337_/C _2135_/X _2001_/X VGND VGND VPWR VPWR _2136_/X sky130_fd_sc_hd__a31o_1
XFILLER_26_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2067_ _2740_/A _2741_/B _2550_/D _2066_/X VGND VGND VPWR VPWR _2112_/B sky130_fd_sc_hd__o211a_1
XFILLER_81_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2969_ _3380_/Q _2906_/X _2968_/X VGND VGND VPWR VPWR _3380_/D sky130_fd_sc_hd__a21o_1
XFILLER_1_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2823_ _2838_/A _2827_/B _2821_/X VGND VGND VPWR VPWR _2829_/A sky130_fd_sc_hd__a21oi_2
X_2754_ _3351_/Q _2801_/C _2745_/X _3208_/Q _2747_/X VGND VGND VPWR VPWR _2754_/X
+ sky130_fd_sc_hd__a221o_1
X_1705_ _1705_/A VGND VGND VPWR VPWR _1810_/C sky130_fd_sc_hd__buf_2
X_2685_ _2086_/B _2337_/C _1677_/Y VGND VGND VPWR VPWR _2685_/X sky130_fd_sc_hd__o21a_1
X_1636_ _1636_/A VGND VGND VPWR VPWR _2494_/B sky130_fd_sc_hd__buf_6
X_1567_ _2889_/B _2813_/C _2837_/A VGND VGND VPWR VPWR _1567_/X sky130_fd_sc_hd__or3b_1
X_3306_ _3343_/CLK _3306_/D VGND VGND VPWR VPWR _3306_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3237_ _3238_/CLK _3237_/D VGND VGND VPWR VPWR _3237_/Q sky130_fd_sc_hd__dfxtp_4
XFILLER_73_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3168_ _3405_/CLK _3168_/D VGND VGND VPWR VPWR _3168_/Q sky130_fd_sc_hd__dfxtp_1
X_2119_ _1679_/B _2188_/A _1740_/B _2118_/Y VGND VGND VPWR VPWR _2119_/X sky130_fd_sc_hd__a31o_1
XFILLER_64_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3099_ _3201_/Q _2895_/A _2825_/B _3108_/C _3098_/X VGND VGND VPWR VPWR _3100_/B
+ sky130_fd_sc_hd__o32a_1
XFILLER_10_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_285 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_458 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_436 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_322 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2470_ _2086_/B _2467_/Y _2469_/X VGND VGND VPWR VPWR _3204_/D sky130_fd_sc_hd__o21ba_1
XFILLER_55_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3022_ _3189_/Q _2907_/X _2909_/X _3021_/X VGND VGND VPWR VPWR _3022_/X sky130_fd_sc_hd__o211a_1
X_2806_ _3055_/A _3093_/A _2806_/S VGND VGND VPWR VPWR _3323_/D sky130_fd_sc_hd__mux2_1
X_2737_ _2318_/A _2577_/D _2726_/C _1964_/D VGND VGND VPWR VPWR _2746_/B sky130_fd_sc_hd__o31a_1
X_2668_ _2668_/A _2668_/B _2668_/C VGND VGND VPWR VPWR _2668_/X sky130_fd_sc_hd__and3_1
X_1619_ _3255_/Q VGND VGND VPWR VPWR _2726_/A sky130_fd_sc_hd__buf_12
X_2599_ _2575_/S _1647_/X _2335_/A _2460_/X VGND VGND VPWR VPWR _2599_/X sky130_fd_sc_hd__a2bb2o_1
XFILLER_59_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_406 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_244 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1970_ _1970_/A VGND VGND VPWR VPWR _2476_/S sky130_fd_sc_hd__clkbuf_4
X_2522_ _3218_/Q _2626_/B _3219_/Q VGND VGND VPWR VPWR _2522_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_5_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2453_ _1608_/X _2431_/X _2446_/X _2452_/X _2494_/A VGND VGND VPWR VPWR _2453_/X
+ sky130_fd_sc_hd__a311o_1
X_2384_ _2434_/B _2384_/B _2384_/C VGND VGND VPWR VPWR _2657_/A sky130_fd_sc_hd__and3_1
Xinput2 i_qspi_dat[1] VGND VGND VPWR VPWR input2/X sky130_fd_sc_hd__clkbuf_1
X_3005_ _3386_/Q _2906_/X _3004_/X VGND VGND VPWR VPWR _3386_/D sky130_fd_sc_hd__a21o_1
XFILLER_36_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_166 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_240 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1953_ _2726_/A _2424_/A _2043_/B _2740_/A VGND VGND VPWR VPWR _2743_/C sky130_fd_sc_hd__or4_1
X_1884_ _3134_/Q _1883_/X _1932_/S VGND VGND VPWR VPWR _3134_/D sky130_fd_sc_hd__mux2_1
X_2505_ _2520_/C _2411_/B _2102_/D _3258_/Q _1656_/X VGND VGND VPWR VPWR _2505_/X
+ sky130_fd_sc_hd__o311a_1
X_2436_ _2436_/A _2492_/A _2436_/C VGND VGND VPWR VPWR _2436_/X sky130_fd_sc_hd__and3_1
X_2367_ _2335_/A _2740_/C _2366_/X _2129_/X VGND VGND VPWR VPWR _2367_/X sky130_fd_sc_hd__o31a_1
X_2298_ _2389_/C input13/X _2297_/X VGND VGND VPWR VPWR _2298_/X sky130_fd_sc_hd__o21a_1
XPHY_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_258 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_283 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3270_ _3278_/CLK _3270_/D VGND VGND VPWR VPWR _3270_/Q sky130_fd_sc_hd__dfxtp_2
XTAP_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2221_ _2389_/A _3180_/Q _2441_/A VGND VGND VPWR VPWR _2221_/X sky130_fd_sc_hd__a21bo_1
XTAP_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2152_ _3172_/Q _2129_/X _2151_/X VGND VGND VPWR VPWR _3172_/D sky130_fd_sc_hd__o21a_1
XFILLER_26_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2083_ _2411_/B _2577_/D _1994_/C _2448_/B _2451_/A VGND VGND VPWR VPWR _2083_/X
+ sky130_fd_sc_hd__o221a_1
XFILLER_34_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2985_ _2982_/X _2826_/X _3100_/A _2984_/X VGND VGND VPWR VPWR _2985_/X sky130_fd_sc_hd__a211o_1
XFILLER_21_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1936_ _3160_/Q _1935_/X _1942_/S VGND VGND VPWR VPWR _3160_/D sky130_fd_sc_hd__mux2_1
X_1867_ _2086_/B _1611_/Y _1866_/Y VGND VGND VPWR VPWR _1872_/C sky130_fd_sc_hd__a21oi_1
Xinput60 i_wb_we VGND VGND VPWR VPWR _1600_/A sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_6_i_clk _3288_/CLK VGND VGND VPWR VPWR _3345_/CLK sky130_fd_sc_hd__clkbuf_16
X_1798_ _1793_/B _1804_/C input13/X _1797_/X VGND VGND VPWR VPWR _1798_/Y sky130_fd_sc_hd__o211ai_1
XFILLER_67_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3399_ _3407_/CLK _3399_/D VGND VGND VPWR VPWR _3399_/Q sky130_fd_sc_hd__dfxtp_1
X_2419_ _3122_/B _2419_/B _2419_/C _2419_/D VGND VGND VPWR VPWR _2419_/X sky130_fd_sc_hd__or4_1
XFILLER_29_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_73 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2770_ _3335_/Q _2768_/X _2740_/C _3302_/Q _2747_/X VGND VGND VPWR VPWR _3302_/D
+ sky130_fd_sc_hd__a32o_1
XFILLER_7_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1721_ _1815_/B _1720_/A _1720_/B VGND VGND VPWR VPWR _1721_/Y sky130_fd_sc_hd__a21oi_1
X_1652_ _2424_/A _2434_/B _2448_/A VGND VGND VPWR VPWR _2004_/B sky130_fd_sc_hd__or3_2
X_1583_ _3250_/Q _3324_/Q VGND VGND VPWR VPWR _1583_/X sky130_fd_sc_hd__and2b_1
X_3322_ _3405_/CLK _3322_/D VGND VGND VPWR VPWR _3322_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3253_ _3255_/CLK _3253_/D VGND VGND VPWR VPWR _3253_/Q sky130_fd_sc_hd__dfxtp_4
X_2204_ _2389_/C input22/X _2203_/X _1608_/X VGND VGND VPWR VPWR _2204_/X sky130_fd_sc_hd__o211a_1
X_3184_ _3330_/CLK _3184_/D VGND VGND VPWR VPWR _3184_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2135_ _2135_/A VGND VGND VPWR VPWR _2135_/X sky130_fd_sc_hd__buf_2
XFILLER_66_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_217 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2066_ _2726_/C _2520_/B _2616_/D _2726_/A VGND VGND VPWR VPWR _2066_/X sky130_fd_sc_hd__or4_4
XFILLER_22_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2968_ _3180_/Q _2907_/X _2909_/X _2967_/X VGND VGND VPWR VPWR _2968_/X sky130_fd_sc_hd__o211a_1
X_1919_ _3151_/Q _3148_/Q _2884_/S VGND VGND VPWR VPWR _1919_/X sky130_fd_sc_hd__mux2_1
X_2899_ _2837_/A _2813_/C _2838_/A _2851_/C _2841_/X VGND VGND VPWR VPWR _2899_/Y
+ sky130_fd_sc_hd__o221ai_1
XFILLER_76_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2822_ _2889_/B _2819_/C _2808_/Y VGND VGND VPWR VPWR _2827_/B sky130_fd_sc_hd__a21o_1
X_2753_ _3293_/Q _2888_/S _2752_/X VGND VGND VPWR VPWR _3293_/D sky130_fd_sc_hd__o21a_1
X_1704_ _3232_/Q _3233_/Q _3234_/Q _3235_/Q VGND VGND VPWR VPWR _1705_/A sky130_fd_sc_hd__and4_1
X_2684_ _2424_/A _2641_/Y _2683_/X _2078_/X VGND VGND VPWR VPWR _3254_/D sky130_fd_sc_hd__o211a_1
X_1635_ _2434_/B _2384_/B _2520_/B VGND VGND VPWR VPWR _1636_/A sky130_fd_sc_hd__and3_1
X_1566_ _3368_/Q VGND VGND VPWR VPWR _2837_/A sky130_fd_sc_hd__clkbuf_4
X_3305_ _3343_/CLK _3305_/D VGND VGND VPWR VPWR _3305_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3236_ _3238_/CLK _3236_/D VGND VGND VPWR VPWR _3236_/Q sky130_fd_sc_hd__dfxtp_4
X_3167_ _3398_/CLK _3167_/D VGND VGND VPWR VPWR _3167_/Q sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_24_i_clk clkbuf_2_2__f_i_clk/X VGND VGND VPWR VPWR _3391_/CLK sky130_fd_sc_hd__clkbuf_16
X_3098_ _2895_/A _2825_/B _3097_/B _3403_/Q VGND VGND VPWR VPWR _3098_/X sky130_fd_sc_hd__a2bb2o_1
X_2118_ _1679_/B _2188_/A _2117_/X VGND VGND VPWR VPWR _2118_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_54_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2049_ _2726_/A _2520_/A _2616_/D VGND VGND VPWR VPWR _2552_/B sky130_fd_sc_hd__and3_1
XFILLER_80_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_135 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3021_ _3018_/X _2826_/X _3100_/A _3020_/X VGND VGND VPWR VPWR _3021_/X sky130_fd_sc_hd__a211o_1
XFILLER_63_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_359 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2805_ _3084_/S VGND VGND VPWR VPWR _3093_/A sky130_fd_sc_hd__buf_12
X_2736_ _2434_/B _2384_/B _2616_/D _1977_/A VGND VGND VPWR VPWR _2746_/A sky130_fd_sc_hd__a31o_1
X_2667_ _2456_/D _2666_/X _1959_/Y VGND VGND VPWR VPWR _2668_/A sky130_fd_sc_hd__a21boi_1
X_1618_ _2594_/B _2424_/A VGND VGND VPWR VPWR _1956_/B sky130_fd_sc_hd__nand2_1
X_2598_ _2590_/X _2597_/Y _1955_/A VGND VGND VPWR VPWR _2598_/Y sky130_fd_sc_hd__o21bai_1
XFILLER_59_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3219_ _3404_/CLK _3219_/D VGND VGND VPWR VPWR _3219_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_67_470 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_256 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2521_ _2517_/Y _2519_/X _2692_/A VGND VGND VPWR VPWR _3218_/D sky130_fd_sc_hd__a21oi_1
XFILLER_5_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2452_ _2726_/B _2447_/X _2451_/X VGND VGND VPWR VPWR _2452_/X sky130_fd_sc_hd__o21ba_1
XFILLER_46_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2383_ _2451_/A _2381_/X _2382_/X _1955_/C _3246_/Q VGND VGND VPWR VPWR _2383_/Y
+ sky130_fd_sc_hd__a32oi_1
X_3004_ _3186_/Q _2907_/X _2909_/X _3003_/X VGND VGND VPWR VPWR _3004_/X sky130_fd_sc_hd__o211a_1
Xinput3 i_qspi_dat[2] VGND VGND VPWR VPWR input3/X sky130_fd_sc_hd__clkbuf_2
XFILLER_24_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2719_ _3281_/Q input44/X _2725_/S VGND VGND VPWR VPWR _3281_/D sky130_fd_sc_hd__mux2_1
XFILLER_10_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_178 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_94 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1952_ _2448_/A _2520_/B _2411_/B _2616_/D VGND VGND VPWR VPWR _1964_/C sky130_fd_sc_hd__or4_1
X_1883_ _3133_/Q input2/X _2884_/S VGND VGND VPWR VPWR _1883_/X sky130_fd_sc_hd__mux2_2
X_2504_ _3213_/Q _2497_/Y _2503_/X _2078_/X VGND VGND VPWR VPWR _3213_/D sky130_fd_sc_hd__o211a_1
X_2435_ _2436_/C _1873_/B _2434_/X _2668_/B VGND VGND VPWR VPWR _2435_/X sky130_fd_sc_hd__o31a_1
X_2366_ _2604_/A input5/X _2616_/B _2365_/X VGND VGND VPWR VPWR _2366_/X sky130_fd_sc_hd__a31o_1
X_2297_ _2389_/A _3188_/Q _2441_/A VGND VGND VPWR VPWR _2297_/X sky130_fd_sc_hd__a21bo_1
XFILLER_71_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_229 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2220_ _3180_/Q _2162_/X _2164_/X _2604_/A _2219_/X VGND VGND VPWR VPWR _2220_/X
+ sky130_fd_sc_hd__a221o_1
XTAP_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2151_ _1608_/X _2143_/X _2144_/X _2150_/X _2247_/D VGND VGND VPWR VPWR _2151_/X
+ sky130_fd_sc_hd__a311o_1
XFILLER_38_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2082_ _2726_/A _2384_/C _2324_/D VGND VGND VPWR VPWR _2451_/A sky130_fd_sc_hd__or3_2
XFILLER_34_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2984_ _2832_/A _3179_/Q _2983_/X _2816_/X VGND VGND VPWR VPWR _2984_/X sky130_fd_sc_hd__o211a_1
XFILLER_34_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1935_ _3159_/Q _3156_/Q _3330_/Q VGND VGND VPWR VPWR _1935_/X sky130_fd_sc_hd__mux2_1
X_1866_ _2097_/B _2739_/C _2644_/B _2739_/A _2644_/D VGND VGND VPWR VPWR _1866_/Y
+ sky130_fd_sc_hd__o2111ai_1
Xinput50 i_wb_data[30] VGND VGND VPWR VPWR input50/X sky130_fd_sc_hd__clkbuf_1
X_1797_ _3244_/Q _2020_/B _1796_/B _3245_/Q VGND VGND VPWR VPWR _1797_/X sky130_fd_sc_hd__a31o_1
X_3398_ _3398_/CLK _3398_/D VGND VGND VPWR VPWR _3398_/Q sky130_fd_sc_hd__dfxtp_1
X_2418_ _3287_/Q _2577_/D _2547_/C _2371_/X VGND VGND VPWR VPWR _2419_/D sky130_fd_sc_hd__o31a_1
X_2349_ _3243_/Q _2577_/D _2120_/B _2341_/C _2348_/X VGND VGND VPWR VPWR _2349_/X
+ sky130_fd_sc_hd__o32a_1
XFILLER_16_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1720_ _1720_/A _1720_/B _1815_/B VGND VGND VPWR VPWR _1720_/X sky130_fd_sc_hd__and3_1
X_1651_ _1679_/B _2188_/A _1650_/Y VGND VGND VPWR VPWR _1653_/A sky130_fd_sc_hd__a21oi_2
X_3321_ _3363_/CLK _3321_/D VGND VGND VPWR VPWR _3321_/Q sky130_fd_sc_hd__dfxtp_1
X_1582_ _3250_/Q _2884_/S VGND VGND VPWR VPWR _1582_/X sky130_fd_sc_hd__and2b_1
XTAP_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3252_ _3353_/CLK _3252_/D VGND VGND VPWR VPWR _3252_/Q sky130_fd_sc_hd__dfxtp_1
X_2203_ _2389_/A _3178_/Q _2441_/A VGND VGND VPWR VPWR _2203_/X sky130_fd_sc_hd__a21bo_1
X_3183_ _3200_/CLK _3183_/D VGND VGND VPWR VPWR _3183_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2134_ _2188_/B _2188_/A _2368_/B VGND VGND VPWR VPWR _2135_/A sky130_fd_sc_hd__or3b_1
XFILLER_66_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2065_ _2065_/A VGND VGND VPWR VPWR _2576_/B sky130_fd_sc_hd__buf_6
XFILLER_81_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2967_ _2964_/X _2826_/X _3100_/A _2966_/X VGND VGND VPWR VPWR _2967_/X sky130_fd_sc_hd__a211o_1
X_1918_ _3151_/Q _1917_/X _1932_/S VGND VGND VPWR VPWR _3151_/D sky130_fd_sc_hd__mux2_1
X_2898_ _2890_/Y _2895_/X _3367_/Q _2897_/X VGND VGND VPWR VPWR _3367_/D sky130_fd_sc_hd__a2bb2o_1
X_1849_ _3255_/Q _3253_/Q _3254_/Q VGND VGND VPWR VPWR _1850_/A sky130_fd_sc_hd__or3b_1
XFILLER_78_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_118 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_5_i_clk _3288_/CLK VGND VGND VPWR VPWR _3343_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_63_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2821_ _2889_/B _2889_/A _1573_/B _2818_/Y _2922_/A VGND VGND VPWR VPWR _2821_/X
+ sky130_fd_sc_hd__a311o_2
XFILLER_31_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2752_ _3350_/Q _2801_/C _2745_/X _3207_/Q _2747_/X VGND VGND VPWR VPWR _2752_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_76_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_450 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1703_ _1703_/A VGND VGND VPWR VPWR _1810_/B sky130_fd_sc_hd__clkbuf_4
X_2683_ _2740_/C _2680_/Y _2681_/X _2682_/X _2692_/C VGND VGND VPWR VPWR _2683_/X
+ sky130_fd_sc_hd__a311o_1
X_1634_ _2043_/B _2740_/A VGND VGND VPWR VPWR _2520_/B sky130_fd_sc_hd__nor2_8
X_1565_ _3367_/Q VGND VGND VPWR VPWR _2813_/C sky130_fd_sc_hd__clkinv_2
X_3304_ _3343_/CLK _3304_/D VGND VGND VPWR VPWR _3304_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3235_ _3238_/CLK _3235_/D VGND VGND VPWR VPWR _3235_/Q sky130_fd_sc_hd__dfxtp_2
XFILLER_39_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3166_ _3405_/CLK _3166_/D VGND VGND VPWR VPWR _3166_/Q sky130_fd_sc_hd__dfxtp_1
X_3097_ _3403_/Q _3097_/B VGND VGND VPWR VPWR _3108_/C sky130_fd_sc_hd__nor2_1
X_2117_ _2188_/A _3287_/Q _2463_/C _2658_/B VGND VGND VPWR VPWR _2117_/X sky130_fd_sc_hd__a211o_1
X_2048_ _3166_/Q VGND VGND VPWR VPWR _2048_/Y sky130_fd_sc_hd__inv_2
XFILLER_54_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3020_ _2832_/A _3185_/Q _3019_/X _2816_/X VGND VGND VPWR VPWR _3020_/X sky130_fd_sc_hd__o211a_1
XFILLER_48_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_143 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_198 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2804_ _3323_/Q VGND VGND VPWR VPWR _3084_/S sky130_fd_sc_hd__buf_6
X_2735_ _3226_/Q _3221_/Q _3227_/Q VGND VGND VPWR VPWR _3290_/D sky130_fd_sc_hd__or3b_1
X_2666_ _2740_/A _3165_/Q _2851_/B VGND VGND VPWR VPWR _2666_/X sky130_fd_sc_hd__or3_1
X_1617_ _2389_/C _1611_/Y _2091_/C _2644_/D VGND VGND VPWR VPWR _1617_/X sky130_fd_sc_hd__o211a_1
X_2597_ _2593_/Y _2595_/X _2596_/X VGND VGND VPWR VPWR _2597_/Y sky130_fd_sc_hd__a21oi_1
XFILLER_59_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3218_ _3405_/CLK _3218_/D VGND VGND VPWR VPWR _3218_/Q sky130_fd_sc_hd__dfxtp_1
X_3149_ _3353_/CLK _3149_/D VGND VGND VPWR VPWR _3149_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_67_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_82_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_235 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_268 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2520_ _2520_/A _2520_/B _2520_/C VGND VGND VPWR VPWR _2692_/A sky130_fd_sc_hd__and3_4
Xclkbuf_leaf_23_i_clk clkbuf_2_2__f_i_clk/X VGND VGND VPWR VPWR _3389_/CLK sky130_fd_sc_hd__clkbuf_16
X_2451_ _2451_/A _2451_/B _2451_/C VGND VGND VPWR VPWR _2451_/X sky130_fd_sc_hd__and3_1
X_2382_ _2520_/C _2411_/B _2448_/B _2594_/B _2075_/B VGND VGND VPWR VPWR _2382_/X
+ sky130_fd_sc_hd__o32a_1
X_3003_ _3000_/X _2826_/X _3100_/A _3002_/X VGND VGND VPWR VPWR _3003_/X sky130_fd_sc_hd__a211o_1
Xinput4 i_qspi_dat[3] VGND VGND VPWR VPWR input4/X sky130_fd_sc_hd__clkbuf_2
XFILLER_36_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_154 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2718_ _3280_/Q input43/X _2725_/S VGND VGND VPWR VPWR _3280_/D sky130_fd_sc_hd__mux2_1
X_2649_ _2448_/B _2648_/X _1661_/A _2335_/A VGND VGND VPWR VPWR _2657_/C sky130_fd_sc_hd__o211a_1
XFILLER_47_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_268 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1951_ _1951_/A VGND VGND VPWR VPWR _2120_/B sky130_fd_sc_hd__buf_8
X_1882_ _3133_/Q _1878_/X _1932_/S VGND VGND VPWR VPWR _3133_/D sky130_fd_sc_hd__mux2_1
X_2503_ _3335_/Q _2110_/C _2502_/X _2499_/X VGND VGND VPWR VPWR _2503_/X sky130_fd_sc_hd__a211o_1
X_2434_ _2448_/A _2434_/B _2424_/A VGND VGND VPWR VPWR _2434_/X sky130_fd_sc_hd__or3b_2
X_2365_ _2389_/A _3196_/Q _2733_/A _2335_/C VGND VGND VPWR VPWR _2365_/X sky130_fd_sc_hd__a31o_1
X_2296_ _3188_/Q _2162_/X _2164_/X _1821_/B _2295_/X VGND VGND VPWR VPWR _2296_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_52_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2150_ _2448_/B _2145_/X _2335_/A _1872_/B _2149_/X VGND VGND VPWR VPWR _2150_/X
+ sky130_fd_sc_hd__o311a_1
X_2081_ _2318_/A _2726_/B _2324_/D _1626_/X VGND VGND VPWR VPWR _2081_/X sky130_fd_sc_hd__o31a_1
XFILLER_19_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2983_ _3055_/A _3182_/Q VGND VGND VPWR VPWR _2983_/X sky130_fd_sc_hd__or2_1
XFILLER_21_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1934_ _3159_/Q _1933_/X _1942_/S VGND VGND VPWR VPWR _3159_/D sky130_fd_sc_hd__mux2_1
X_1865_ _2604_/A input5/X VGND VGND VPWR VPWR _2644_/B sky130_fd_sc_hd__nand2_1
Xinput40 i_wb_data[21] VGND VGND VPWR VPWR input40/X sky130_fd_sc_hd__clkbuf_1
Xinput51 i_wb_data[31] VGND VGND VPWR VPWR _2097_/B sky130_fd_sc_hd__buf_2
X_1796_ _2020_/B _1796_/B VGND VGND VPWR VPWR _1804_/C sky130_fd_sc_hd__nand2_1
X_2417_ _2585_/A _2135_/X _2357_/X _3248_/Q _2341_/B VGND VGND VPWR VPWR _2419_/C
+ sky130_fd_sc_hd__o221a_1
X_3397_ _3397_/CLK _3397_/D VGND VGND VPWR VPWR _3397_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_69_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2348_ _2135_/X _2585_/A _2001_/X _2347_/X VGND VGND VPWR VPWR _2348_/X sky130_fd_sc_hd__o31a_1
X_2279_ _3186_/Q _2129_/X _2275_/X _2278_/X VGND VGND VPWR VPWR _3186_/D sky130_fd_sc_hd__o22a_1
XFILLER_44_219 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_46 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1650_ _2368_/B _2188_/B VGND VGND VPWR VPWR _1650_/Y sky130_fd_sc_hd__nor2_1
XFILLER_7_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1581_ _3330_/Q VGND VGND VPWR VPWR _2884_/S sky130_fd_sc_hd__buf_12
X_3320_ _3363_/CLK _3320_/D VGND VGND VPWR VPWR _3320_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3251_ _3255_/CLK _3251_/D VGND VGND VPWR VPWR _3251_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_21_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2202_ _2188_/B _3178_/Q _2389_/A _2044_/X VGND VGND VPWR VPWR _2202_/X sky130_fd_sc_hd__a31o_1
X_3182_ _3330_/CLK _3182_/D VGND VGND VPWR VPWR _3182_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2133_ _2188_/B _2188_/A VGND VGND VPWR VPWR _2337_/C sky130_fd_sc_hd__nand2_4
XFILLER_81_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2064_ _2313_/C _2384_/C _2740_/A VGND VGND VPWR VPWR _2065_/A sky130_fd_sc_hd__and3_1
XFILLER_34_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2966_ _2832_/A _3176_/Q _2965_/X _2816_/X VGND VGND VPWR VPWR _2966_/X sky130_fd_sc_hd__o211a_1
X_1917_ _3150_/Q _3147_/Q _2884_/S VGND VGND VPWR VPWR _1917_/X sky130_fd_sc_hd__mux2_1
X_2897_ _2838_/A _2838_/B _2896_/C _2896_/X _2818_/Y VGND VGND VPWR VPWR _2897_/X
+ sky130_fd_sc_hd__a311o_1
X_1848_ _3165_/Q _2851_/B _2633_/B VGND VGND VPWR VPWR _2120_/C sky130_fd_sc_hd__or3b_4
X_1779_ _3238_/Q _1778_/Y _2008_/A input6/X VGND VGND VPWR VPWR _1780_/B sky130_fd_sc_hd__o211ai_1
XFILLER_57_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_436 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2820_ _2820_/A VGND VGND VPWR VPWR _2922_/A sky130_fd_sc_hd__clkbuf_4
X_2751_ _3292_/Q _2888_/S _2750_/X VGND VGND VPWR VPWR _3292_/D sky130_fd_sc_hd__o21a_1
XFILLER_8_462 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1702_ _2585_/A _2368_/B _3230_/Q _3231_/Q VGND VGND VPWR VPWR _1703_/A sky130_fd_sc_hd__and4_1
X_2682_ _2630_/B _2098_/C _2606_/B _2091_/C VGND VGND VPWR VPWR _2682_/X sky130_fd_sc_hd__o31a_1
X_1633_ _3255_/Q _2424_/A VGND VGND VPWR VPWR _2384_/B sky130_fd_sc_hd__nor2_1
X_1564_ _3369_/Q VGND VGND VPWR VPWR _2889_/B sky130_fd_sc_hd__buf_6
X_3303_ _3343_/CLK _3303_/D VGND VGND VPWR VPWR _3303_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3234_ _3238_/CLK _3234_/D VGND VGND VPWR VPWR _3234_/Q sky130_fd_sc_hd__dfxtp_2
XTAP_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3165_ _3203_/CLK _3165_/D VGND VGND VPWR VPWR _3165_/Q sky130_fd_sc_hd__dfxtp_4
X_3096_ _3100_/A _3094_/X _3101_/S _3402_/Q VGND VGND VPWR VPWR _3402_/D sky130_fd_sc_hd__a2bb2o_1
X_2116_ _2188_/B _2188_/A VGND VGND VPWR VPWR _2658_/B sky130_fd_sc_hd__and2_2
XFILLER_39_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_155 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2047_ _3165_/Q _2626_/B _1990_/X _2046_/X VGND VGND VPWR VPWR _3165_/D sky130_fd_sc_hd__o22a_1
XFILLER_13_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2949_ _2946_/X _2826_/X _3100_/A _2948_/X VGND VGND VPWR VPWR _2949_/X sky130_fd_sc_hd__a211o_1
XFILLER_72_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_155 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2803_ _3168_/Q _3322_/Q _2806_/S VGND VGND VPWR VPWR _3322_/D sky130_fd_sc_hd__mux2_1
X_2734_ _2188_/B _2717_/S _2733_/X VGND VGND VPWR VPWR _3289_/D sky130_fd_sc_hd__o21ai_1
X_2665_ _2585_/A _2368_/B _2368_/C _2658_/B VGND VGND VPWR VPWR _2665_/X sky130_fd_sc_hd__a31o_1
X_2596_ _3248_/Q _2616_/D _2492_/A _2312_/X VGND VGND VPWR VPWR _2596_/X sky130_fd_sc_hd__a31o_1
X_1616_ _1616_/A VGND VGND VPWR VPWR _2644_/D sky130_fd_sc_hd__buf_6
XFILLER_5_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3217_ _3409_/CLK _3217_/D VGND VGND VPWR VPWR _3217_/Q sky130_fd_sc_hd__dfxtp_1
X_3148_ _3353_/CLK _3148_/D VGND VGND VPWR VPWR _3148_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_27_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3079_ _3167_/Q _3198_/Q VGND VGND VPWR VPWR _3079_/X sky130_fd_sc_hd__or2_1
XFILLER_42_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_4_i_clk _3288_/CLK VGND VGND VPWR VPWR _3338_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_2_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2450_ _2476_/S _2448_/X _2668_/B _2436_/X _2449_/X VGND VGND VPWR VPWR _2451_/B
+ sky130_fd_sc_hd__a311o_1
XFILLER_53_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2381_ _2312_/X _1740_/B _2368_/C _2380_/X VGND VGND VPWR VPWR _2381_/X sky130_fd_sc_hd__a31o_1
X_3002_ _2832_/A _3182_/Q _3001_/X _2816_/X VGND VGND VPWR VPWR _3002_/X sky130_fd_sc_hd__o211a_1
Xinput5 i_wb_addr[0] VGND VGND VPWR VPWR input5/X sky130_fd_sc_hd__buf_4
XFILLER_24_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_166 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2717_ _3279_/Q input42/X _2717_/S VGND VGND VPWR VPWR _3279_/D sky130_fd_sc_hd__mux2_1
XFILLER_10_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2648_ _3200_/Q _3331_/Q _3165_/Q VGND VGND VPWR VPWR _2648_/X sky130_fd_sc_hd__and3b_1
X_2579_ _3248_/Q _2575_/X _2579_/S VGND VGND VPWR VPWR _3248_/D sky130_fd_sc_hd__mux2_1
XFILLER_59_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_99 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1950_ _3255_/Q _3254_/Q _3253_/Q VGND VGND VPWR VPWR _1951_/A sky130_fd_sc_hd__or3b_1
X_1881_ _1942_/S VGND VGND VPWR VPWR _1932_/S sky130_fd_sc_hd__clkbuf_16
X_2502_ _2520_/C _2411_/B _2102_/D _3257_/Q _1656_/X VGND VGND VPWR VPWR _2502_/X
+ sky130_fd_sc_hd__o311a_1
XFILLER_51_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2433_ _1679_/B _2188_/A _3248_/Q _2585_/A _2135_/X VGND VGND VPWR VPWR _2433_/X
+ sky130_fd_sc_hd__o32a_1
X_2364_ _2733_/A _2739_/A _2644_/D VGND VGND VPWR VPWR _2616_/B sky130_fd_sc_hd__nor3b_2
X_2295_ _3237_/Q _2577_/D _2120_/B _2294_/X VGND VGND VPWR VPWR _2295_/X sky130_fd_sc_hd__o31a_1
XFILLER_56_239 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_180 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_22_i_clk clkbuf_2_2__f_i_clk/X VGND VGND VPWR VPWR _3388_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_15_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2080_ _1854_/Y _1873_/B _2076_/D VGND VGND VPWR VPWR _2080_/Y sky130_fd_sc_hd__a21oi_1
XFILLER_46_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_231 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2982_ _3382_/Q _3379_/Q _3093_/A VGND VGND VPWR VPWR _2982_/X sky130_fd_sc_hd__mux2_1
X_1933_ _3158_/Q _3155_/Q _3330_/Q VGND VGND VPWR VPWR _1933_/X sky130_fd_sc_hd__mux2_1
Xinput30 i_wb_data[12] VGND VGND VPWR VPWR input30/X sky130_fd_sc_hd__clkbuf_1
X_1864_ _2740_/B VGND VGND VPWR VPWR _2733_/A sky130_fd_sc_hd__clkbuf_16
Xinput52 i_wb_data[3] VGND VGND VPWR VPWR input52/X sky130_fd_sc_hd__clkbuf_1
X_1795_ _1793_/Y _1794_/Y input13/X VGND VGND VPWR VPWR _1795_/Y sky130_fd_sc_hd__o21bai_1
Xinput41 i_wb_data[22] VGND VGND VPWR VPWR input41/X sky130_fd_sc_hd__clkbuf_1
X_2416_ _2415_/X _2733_/A _2393_/X _2604_/A _2388_/X VGND VGND VPWR VPWR _2416_/X
+ sky130_fd_sc_hd__a32o_1
X_3396_ _3397_/CLK _3396_/D VGND VGND VPWR VPWR _3396_/Q sky130_fd_sc_hd__dfxtp_1
X_2347_ _2318_/A _3281_/Q _1644_/X _2137_/X VGND VGND VPWR VPWR _2347_/X sky130_fd_sc_hd__a31o_1
X_2278_ _2733_/A _2090_/X _2277_/X _2247_/D VGND VGND VPWR VPWR _2278_/X sky130_fd_sc_hd__a31o_1
XFILLER_44_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1580_ _3329_/Q _3250_/Q VGND VGND VPWR VPWR _1580_/X sky130_fd_sc_hd__or2_1
XTAP_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3250_ _3405_/CLK _3250_/D VGND VGND VPWR VPWR _3250_/Q sky130_fd_sc_hd__dfxtp_2
XTAP_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2201_ _2384_/C _2594_/B _1854_/Y _2199_/X _2200_/X VGND VGND VPWR VPWR _2201_/X
+ sky130_fd_sc_hd__a32o_1
X_3181_ _3330_/CLK _3181_/D VGND VGND VPWR VPWR _3181_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2132_ _2188_/B _3171_/Q _2161_/B _2120_/B VGND VGND VPWR VPWR _2132_/X sky130_fd_sc_hd__a31o_1
XFILLER_81_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2063_ _2063_/A VGND VGND VPWR VPWR _2552_/A sky130_fd_sc_hd__buf_6
XFILLER_81_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2965_ _3055_/A _3179_/Q VGND VGND VPWR VPWR _2965_/X sky130_fd_sc_hd__or2_1
X_1916_ _3150_/Q _1915_/X _1932_/S VGND VGND VPWR VPWR _3150_/D sky130_fd_sc_hd__mux2_1
X_2896_ _2837_/A _2889_/B _2896_/C _3367_/Q VGND VGND VPWR VPWR _2896_/X sky130_fd_sc_hd__and4bb_1
XFILLER_30_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1847_ _1683_/X _2550_/D _2626_/D _2741_/B _1846_/X VGND VGND VPWR VPWR _1847_/Y
+ sky130_fd_sc_hd__o2111ai_1
X_1778_ _1778_/A _1778_/B _1815_/B _1815_/C VGND VGND VPWR VPWR _1778_/Y sky130_fd_sc_hd__nor4_2
XFILLER_1_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3379_ _3391_/CLK _3379_/D VGND VGND VPWR VPWR _3379_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_57_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2750_ _3349_/Q _2801_/C _2745_/X _3206_/Q _2747_/X VGND VGND VPWR VPWR _2750_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_8_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1701_ _3240_/Q _2020_/B _2020_/D _3241_/Q VGND VGND VPWR VPWR _1701_/X sky130_fd_sc_hd__a31o_1
X_2681_ _2040_/B _1679_/B _2726_/B _2120_/B VGND VGND VPWR VPWR _2681_/X sky130_fd_sc_hd__a211o_1
XFILLER_8_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1632_ _3165_/Q _2436_/A VGND VGND VPWR VPWR _2613_/A sky130_fd_sc_hd__nor2_4
X_1563_ _3332_/Q VGND VGND VPWR VPWR _2896_/C sky130_fd_sc_hd__clkbuf_8
X_3302_ _3343_/CLK _3302_/D VGND VGND VPWR VPWR _3302_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3233_ _3330_/CLK _3233_/D VGND VGND VPWR VPWR _3233_/Q sky130_fd_sc_hd__dfxtp_2
XFILLER_39_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3164_ _3345_/CLK _3164_/D VGND VGND VPWR VPWR _3164_/Q sky130_fd_sc_hd__dfxtp_1
X_3095_ _2896_/C _2838_/B _2838_/A _2906_/A VGND VGND VPWR VPWR _3101_/S sky130_fd_sc_hd__a31o_1
X_2115_ _2044_/X _2613_/A _1653_/X _2547_/B _2428_/B VGND VGND VPWR VPWR _2115_/X
+ sky130_fd_sc_hd__o2111a_1
XFILLER_81_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2046_ _2114_/C _2494_/A _1858_/X _2039_/X _2045_/X VGND VGND VPWR VPWR _2046_/X
+ sky130_fd_sc_hd__a32o_1
XFILLER_66_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2948_ _2832_/A _3173_/Q _2947_/X _2816_/X VGND VGND VPWR VPWR _2948_/X sky130_fd_sc_hd__o211a_1
X_2879_ _3360_/Q _1933_/X _2885_/S VGND VGND VPWR VPWR _3360_/D sky130_fd_sc_hd__mux2_1
XFILLER_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_212 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_178 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2802_ _3321_/Q _2747_/X _2801_/X VGND VGND VPWR VPWR _3321_/D sky130_fd_sc_hd__a21o_1
X_2733_ _2733_/A _2740_/C _2644_/D VGND VGND VPWR VPWR _2733_/X sky130_fd_sc_hd__or3b_1
X_2664_ _3203_/Q _2664_/B VGND VGND VPWR VPWR _2664_/Y sky130_fd_sc_hd__nor2_1
X_2595_ _2114_/D _2004_/B _2594_/Y _2187_/X VGND VGND VPWR VPWR _2595_/X sky130_fd_sc_hd__o22a_1
X_1615_ _2740_/B _1872_/B VGND VGND VPWR VPWR _2091_/C sky130_fd_sc_hd__nor2_2
X_3216_ _3409_/CLK _3216_/D VGND VGND VPWR VPWR _3216_/Q sky130_fd_sc_hd__dfxtp_1
X_3147_ _3350_/CLK _3147_/D VGND VGND VPWR VPWR _3147_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_54_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_112 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3078_ _3398_/Q _3395_/Q _3084_/S VGND VGND VPWR VPWR _3078_/X sky130_fd_sc_hd__mux2_1
XFILLER_54_156 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_329 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2029_ _2027_/Y _1772_/B input13/X _2028_/X VGND VGND VPWR VPWR _2029_/Y sky130_fd_sc_hd__a22oi_1
XFILLER_2_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_18 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_307 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2380_ _2448_/A _2726_/B _2324_/D _2001_/X _2379_/X VGND VGND VPWR VPWR _2380_/X
+ sky130_fd_sc_hd__o311a_1
XFILLER_68_204 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3001_ _3055_/A _3185_/Q VGND VGND VPWR VPWR _3001_/X sky130_fd_sc_hd__or2_1
Xinput6 i_wb_addr[10] VGND VGND VPWR VPWR input6/X sky130_fd_sc_hd__buf_2
XFILLER_36_178 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_126 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2716_ _3278_/Q input41/X _2717_/S VGND VGND VPWR VPWR _3278_/D sky130_fd_sc_hd__mux2_1
XFILLER_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2647_ _2384_/C _2594_/B _1661_/A _3122_/B VGND VGND VPWR VPWR _2657_/B sky130_fd_sc_hd__a31o_1
XFILLER_10_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2578_ _2448_/X _1998_/C _1994_/C _2576_/X _2738_/D VGND VGND VPWR VPWR _2579_/S
+ sky130_fd_sc_hd__o2111a_1
XFILLER_59_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1880_ _1880_/A VGND VGND VPWR VPWR _1942_/S sky130_fd_sc_hd__buf_2
X_2501_ _3212_/Q _2497_/Y _2500_/X _2078_/X VGND VGND VPWR VPWR _3212_/D sky130_fd_sc_hd__o211a_1
X_2432_ _2733_/A _2430_/Y _2431_/X _2353_/Y VGND VGND VPWR VPWR _2432_/X sky130_fd_sc_hd__a31o_1
XFILLER_44_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2363_ _3195_/Q _2129_/X _2362_/X _2344_/X VGND VGND VPWR VPWR _3195_/D sky130_fd_sc_hd__o22a_1
X_2294_ _2520_/C _1644_/X _2257_/X _3245_/Q _2293_/X VGND VGND VPWR VPWR _2294_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_56_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_3_i_clk _3288_/CLK VGND VGND VPWR VPWR _3287_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_64_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2981_ _3382_/Q _2906_/X _2980_/X VGND VGND VPWR VPWR _3382_/D sky130_fd_sc_hd__a21o_1
XFILLER_61_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1932_ _3158_/Q _1931_/X _1932_/S VGND VGND VPWR VPWR _3158_/D sky130_fd_sc_hd__mux2_1
XFILLER_14_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1863_ _1682_/X _1857_/Y _1862_/X VGND VGND VPWR VPWR _1863_/Y sky130_fd_sc_hd__o21ai_1
Xinput20 i_wb_addr[5] VGND VGND VPWR VPWR _1749_/A sky130_fd_sc_hd__clkbuf_2
Xinput31 i_wb_data[13] VGND VGND VPWR VPWR input31/X sky130_fd_sc_hd__clkbuf_1
Xinput53 i_wb_data[4] VGND VGND VPWR VPWR input53/X sky130_fd_sc_hd__clkbuf_1
X_1794_ _3244_/Q _2020_/B _1796_/B _3245_/Q VGND VGND VPWR VPWR _1794_/Y sky130_fd_sc_hd__a31oi_1
Xinput42 i_wb_data[23] VGND VGND VPWR VPWR input42/X sky130_fd_sc_hd__clkbuf_1
X_2415_ _2161_/B _3200_/Q _2441_/A VGND VGND VPWR VPWR _2415_/X sky130_fd_sc_hd__a21bo_1
X_3395_ _3397_/CLK _3395_/D VGND VGND VPWR VPWR _3395_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_69_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2346_ _1679_/B _3194_/Q _1987_/Y _1740_/B _2146_/X VGND VGND VPWR VPWR _2346_/X
+ sky130_fd_sc_hd__o32a_1
XFILLER_69_354 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2277_ _2389_/C _1804_/B _2276_/X VGND VGND VPWR VPWR _2277_/X sky130_fd_sc_hd__o21a_1
XFILLER_16_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_413 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_58 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_379 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2200_ _3265_/Q _2552_/A _2576_/B _3257_/Q _2137_/X VGND VGND VPWR VPWR _2200_/X
+ sky130_fd_sc_hd__a221o_1
XTAP_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3180_ _3330_/CLK _3180_/D VGND VGND VPWR VPWR _3180_/Q sky130_fd_sc_hd__dfxtp_1
X_2131_ _2389_/A _3171_/Q _2389_/C VGND VGND VPWR VPWR _2131_/X sky130_fd_sc_hd__a21bo_1
XFILLER_66_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2062_ _2448_/B _2492_/B _2594_/B VGND VGND VPWR VPWR _2063_/A sky130_fd_sc_hd__and3_1
XFILLER_34_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_276 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2964_ _3379_/Q _3376_/Q _3093_/A VGND VGND VPWR VPWR _2964_/X sky130_fd_sc_hd__mux2_1
X_1915_ _3149_/Q _3146_/Q _2884_/S VGND VGND VPWR VPWR _1915_/X sky130_fd_sc_hd__mux2_1
X_2895_ _2895_/A _2895_/B _2895_/C _2896_/C VGND VGND VPWR VPWR _2895_/X sky130_fd_sc_hd__or4b_1
X_1846_ _1647_/X _1845_/Y _1665_/A _2520_/C VGND VGND VPWR VPWR _1846_/X sky130_fd_sc_hd__a2bb2o_1
X_1777_ _3237_/Q VGND VGND VPWR VPWR _1778_/B sky130_fd_sc_hd__inv_2
Xclkbuf_leaf_21_i_clk clkbuf_2_2__f_i_clk/X VGND VGND VPWR VPWR _3330_/CLK sky130_fd_sc_hd__clkbuf_16
X_3378_ _3391_/CLK _3378_/D VGND VGND VPWR VPWR _3378_/Q sky130_fd_sc_hd__dfxtp_1
X_2329_ _3217_/Q _2576_/B _2291_/X _3263_/Q _1644_/X VGND VGND VPWR VPWR _2329_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_57_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_368 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2680_ _2657_/A _2680_/B _2680_/C VGND VGND VPWR VPWR _2680_/Y sky130_fd_sc_hd__nand3b_1
X_1700_ _1700_/A VGND VGND VPWR VPWR _2020_/D sky130_fd_sc_hd__buf_2
X_1631_ _2851_/B _2633_/B VGND VGND VPWR VPWR _2436_/A sky130_fd_sc_hd__or2b_2
X_1562_ _3165_/Q VGND VGND VPWR VPWR _2851_/A sky130_fd_sc_hd__clkinv_2
X_3301_ _3338_/CLK _3301_/D VGND VGND VPWR VPWR _3301_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3232_ _3388_/CLK _3232_/D VGND VGND VPWR VPWR _3232_/Q sky130_fd_sc_hd__dfxtp_4
XTAP_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3163_ _3365_/CLK _3163_/D VGND VGND VPWR VPWR _3163_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_39_357 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2114_ _2411_/B _2726_/A _2114_/C _2114_/D VGND VGND VPWR VPWR _2428_/B sky130_fd_sc_hd__or4_1
XFILLER_66_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3094_ _3108_/D _3097_/B _3093_/X _2906_/A VGND VGND VPWR VPWR _3094_/X sky130_fd_sc_hd__a31o_1
X_2045_ _2040_/X _2042_/X _2613_/A _2044_/X VGND VGND VPWR VPWR _2045_/X sky130_fd_sc_hd__a31o_1
X_2947_ _3055_/A _3176_/Q VGND VGND VPWR VPWR _2947_/X sky130_fd_sc_hd__or2_1
X_2878_ _3359_/Q _1931_/X _2885_/S VGND VGND VPWR VPWR _3359_/D sky130_fd_sc_hd__mux2_1
X_1829_ _3255_/Q _2424_/A _1994_/B VGND VGND VPWR VPWR _1830_/A sky130_fd_sc_hd__and3_1
XTAP_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_176 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_463 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2801_ _3360_/Q _2888_/S _2801_/C VGND VGND VPWR VPWR _2801_/X sky130_fd_sc_hd__and3_1
X_2732_ _3288_/Q _2616_/C _1873_/B _2731_/X VGND VGND VPWR VPWR _3288_/D sky130_fd_sc_hd__a31o_1
XFILLER_74_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2663_ _2448_/B _2641_/Y _2662_/X _2078_/X VGND VGND VPWR VPWR _3252_/D sky130_fd_sc_hd__o211a_1
X_2594_ _2851_/B _2594_/B VGND VGND VPWR VPWR _2594_/Y sky130_fd_sc_hd__nor2_1
X_1614_ _1614_/A VGND VGND VPWR VPWR _1872_/B sky130_fd_sc_hd__buf_6
X_3215_ _3409_/CLK _3215_/D VGND VGND VPWR VPWR _3215_/Q sky130_fd_sc_hd__dfxtp_1
X_3146_ _3350_/CLK _3146_/D VGND VGND VPWR VPWR _3146_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_82_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3077_ _3398_/Q _2906_/X _3076_/X VGND VGND VPWR VPWR _3398_/D sky130_fd_sc_hd__a21o_1
XFILLER_54_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2028_ _2021_/C _1818_/B _1819_/C _1766_/B VGND VGND VPWR VPWR _2028_/X sky130_fd_sc_hd__a22o_1
XFILLER_40_47 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_319 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_190 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_374 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3000_ _3385_/Q _3382_/Q _3093_/A VGND VGND VPWR VPWR _3000_/X sky130_fd_sc_hd__mux2_1
Xinput7 i_wb_addr[11] VGND VGND VPWR VPWR input7/X sky130_fd_sc_hd__buf_2
XFILLER_64_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2715_ _3277_/Q input40/X _2717_/S VGND VGND VPWR VPWR _3277_/D sky130_fd_sc_hd__mux2_1
X_2646_ _2733_/A _1986_/Y _2393_/X _2645_/Y VGND VGND VPWR VPWR _2646_/X sky130_fd_sc_hd__a31o_1
X_2577_ _2726_/A _2726_/C _3331_/Q _2577_/D VGND VGND VPWR VPWR _2738_/D sky130_fd_sc_hd__or4_1
XFILLER_19_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3129_ _3409_/Q _3124_/Y _3128_/X _2078_/X VGND VGND VPWR VPWR _3409_/D sky130_fd_sc_hd__o211a_1
XFILLER_23_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2500_ _3334_/Q _2110_/C _2498_/X _2499_/X VGND VGND VPWR VPWR _2500_/X sky130_fd_sc_hd__a211o_1
X_2431_ _2739_/A _3248_/Q VGND VGND VPWR VPWR _2431_/X sky130_fd_sc_hd__or2b_1
XFILLER_37_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2362_ _1608_/X _2356_/Y _2090_/X _2361_/X VGND VGND VPWR VPWR _2362_/X sky130_fd_sc_hd__o2bb2a_1
X_2293_ _3275_/Q _1844_/B _2290_/X _2292_/X VGND VGND VPWR VPWR _2293_/X sky130_fd_sc_hd__o22a_1
XFILLER_49_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_190 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2629_ _2097_/B _2739_/C _2644_/B VGND VGND VPWR VPWR _2629_/X sky130_fd_sc_hd__o21a_1
XFILLER_46_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2980_ _3182_/Q _2907_/X _2909_/X _2979_/X VGND VGND VPWR VPWR _2980_/X sky130_fd_sc_hd__o211a_1
X_1931_ _3157_/Q _3154_/Q _3330_/Q VGND VGND VPWR VPWR _1931_/X sky130_fd_sc_hd__mux2_1
XFILLER_61_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1862_ _1672_/X _1858_/X _2335_/A _2740_/C VGND VGND VPWR VPWR _1862_/X sky130_fd_sc_hd__o2bb2a_1
Xinput21 i_wb_addr[6] VGND VGND VPWR VPWR _1730_/B sky130_fd_sc_hd__buf_2
Xinput10 i_wb_addr[14] VGND VGND VPWR VPWR _2335_/B sky130_fd_sc_hd__clkbuf_2
Xinput54 i_wb_data[5] VGND VGND VPWR VPWR input54/X sky130_fd_sc_hd__clkbuf_1
Xinput32 i_wb_data[14] VGND VGND VPWR VPWR input32/X sky130_fd_sc_hd__clkbuf_1
X_1793_ _1815_/B _1793_/B _1815_/C _1796_/B VGND VGND VPWR VPWR _1793_/Y sky130_fd_sc_hd__nor4b_1
Xinput43 i_wb_data[24] VGND VGND VPWR VPWR input43/X sky130_fd_sc_hd__clkbuf_1
XFILLER_6_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2414_ _3199_/Q _2129_/X _2413_/X VGND VGND VPWR VPWR _3199_/D sky130_fd_sc_hd__o21a_1
XFILLER_69_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3394_ _3397_/CLK _3394_/D VGND VGND VPWR VPWR _3394_/Q sky130_fd_sc_hd__dfxtp_1
X_2345_ _2334_/Y _2343_/X _2344_/X _2129_/X _3193_/Q VGND VGND VPWR VPWR _3193_/D
+ sky130_fd_sc_hd__o32a_1
XFILLER_69_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2276_ _2389_/A _3186_/Q _2441_/A VGND VGND VPWR VPWR _2276_/X sky130_fd_sc_hd__a21bo_1
XFILLER_69_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2130_ _2739_/A input5/X VGND VGND VPWR VPWR _2130_/X sky130_fd_sc_hd__or2_1
X_2061_ _3167_/Q VGND VGND VPWR VPWR _3055_/A sky130_fd_sc_hd__buf_6
XFILLER_81_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2963_ _3379_/Q _2906_/X _2962_/X VGND VGND VPWR VPWR _3379_/D sky130_fd_sc_hd__a21o_1
XFILLER_22_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1914_ _3149_/Q _1913_/X _1932_/S VGND VGND VPWR VPWR _3149_/D sky130_fd_sc_hd__mux2_1
X_2894_ _2891_/X _2893_/X _2825_/B VGND VGND VPWR VPWR _2895_/C sky130_fd_sc_hd__o21a_1
X_1845_ _1998_/C _2575_/S _1834_/Y _1844_/X VGND VGND VPWR VPWR _1845_/Y sky130_fd_sc_hd__a22oi_1
X_1776_ _2008_/A _2008_/B input6/X VGND VGND VPWR VPWR _1780_/A sky130_fd_sc_hd__a21o_1
X_3377_ _3397_/CLK _3377_/D VGND VGND VPWR VPWR _3377_/Q sky130_fd_sc_hd__dfxtp_1
X_2328_ _1872_/B _2129_/X _2327_/X _2123_/X _3191_/Q VGND VGND VPWR VPWR _3191_/D
+ sky130_fd_sc_hd__a32o_1
XFILLER_69_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2259_ _2259_/A VGND VGND VPWR VPWR _2547_/C sky130_fd_sc_hd__clkbuf_4
XFILLER_25_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_398 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_450 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1630_ _2585_/A _2368_/B VGND VGND VPWR VPWR _1630_/Y sky130_fd_sc_hd__nor2_2
XFILLER_69_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1561_ _3328_/Q _3290_/Q _3250_/Q VGND VGND VPWR VPWR _2633_/B sky130_fd_sc_hd__mux2_2
X_3300_ _3366_/CLK _3300_/D VGND VGND VPWR VPWR _3300_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3231_ _3330_/CLK _3231_/D VGND VGND VPWR VPWR _3231_/Q sky130_fd_sc_hd__dfxtp_2
XTAP_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3162_ _3366_/CLK _3162_/D VGND VGND VPWR VPWR _3162_/Q sky130_fd_sc_hd__dfxtp_1
X_2113_ _2424_/A _2384_/C _2594_/B _2448_/A VGND VGND VPWR VPWR _2547_/B sky130_fd_sc_hd__or4_1
XFILLER_66_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3093_ _3093_/A _3093_/B _3402_/Q VGND VGND VPWR VPWR _3093_/X sky130_fd_sc_hd__or3b_1
XFILLER_39_369 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_166 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2044_ _2044_/A VGND VGND VPWR VPWR _2044_/X sky130_fd_sc_hd__buf_4
XFILLER_81_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2946_ _3376_/Q _3373_/Q _3093_/A VGND VGND VPWR VPWR _2946_/X sky130_fd_sc_hd__mux2_1
X_2877_ _3358_/Q _1929_/X _3331_/D VGND VGND VPWR VPWR _3358_/D sky130_fd_sc_hd__mux2_1
X_1828_ _3253_/Q _2043_/B VGND VGND VPWR VPWR _1994_/B sky130_fd_sc_hd__nor2_2
X_1759_ _1756_/X _1758_/Y input17/X VGND VGND VPWR VPWR _1759_/Y sky130_fd_sc_hd__o21bai_1
XFILLER_57_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_188 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_229 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_20_i_clk clkbuf_2_2__f_i_clk/X VGND VGND VPWR VPWR _3238_/CLK sky130_fd_sc_hd__clkbuf_16
X_2800_ _3320_/Q _2747_/X _2799_/X VGND VGND VPWR VPWR _3320_/D sky130_fd_sc_hd__a21o_1
XFILLER_12_280 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2731_ _2644_/D _2733_/A _2740_/C _2730_/X VGND VGND VPWR VPWR _2731_/X sky130_fd_sc_hd__o31a_1
XFILLER_8_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2662_ _2090_/X _2646_/X _2692_/C _2661_/Y VGND VGND VPWR VPWR _2662_/X sky130_fd_sc_hd__a211o_1
X_2593_ _2616_/D _2547_/C _2592_/Y VGND VGND VPWR VPWR _2593_/Y sky130_fd_sc_hd__o21ai_1
X_1613_ _3255_/Q _3254_/Q _3253_/Q _2577_/D VGND VGND VPWR VPWR _1614_/A sky130_fd_sc_hd__or4_1
XFILLER_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3214_ _3278_/CLK _3214_/D VGND VGND VPWR VPWR _3214_/Q sky130_fd_sc_hd__dfxtp_1
X_3145_ _3350_/CLK _3145_/D VGND VGND VPWR VPWR _3145_/Q sky130_fd_sc_hd__dfxtp_1
X_3076_ _3198_/Q _2907_/X _2909_/X _3075_/X VGND VGND VPWR VPWR _3076_/X sky130_fd_sc_hd__o211a_1
X_2027_ _2027_/A _2027_/B VGND VGND VPWR VPWR _2027_/Y sky130_fd_sc_hd__nand2_1
XFILLER_50_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_180 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2929_ _3055_/A _3173_/Q VGND VGND VPWR VPWR _2929_/X sky130_fd_sc_hd__or2_1
XFILLER_50_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_59 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_79 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput8 i_wb_addr[12] VGND VGND VPWR VPWR input8/X sky130_fd_sc_hd__buf_2
XFILLER_76_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_456 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2714_ _3276_/Q input39/X _2717_/S VGND VGND VPWR VPWR _3276_/D sky130_fd_sc_hd__mux2_1
X_2645_ _2606_/X _2441_/A _2644_/D _2733_/A _2644_/X VGND VGND VPWR VPWR _2645_/Y
+ sky130_fd_sc_hd__a311oi_1
X_2576_ _2612_/D _2576_/B _2576_/C VGND VGND VPWR VPWR _2576_/X sky130_fd_sc_hd__or3_1
XFILLER_82_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3128_ _3340_/Q _2110_/C _2291_/X _3262_/Q _3125_/X VGND VGND VPWR VPWR _3128_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_55_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3059_ _3395_/Q _2906_/X _3058_/X VGND VGND VPWR VPWR _3395_/D sky130_fd_sc_hd__a21o_1
XFILLER_50_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_279 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_283 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_297 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_80 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2430_ _2430_/A _2441_/A VGND VGND VPWR VPWR _2430_/Y sky130_fd_sc_hd__nand2_1
X_2361_ input12/X _2164_/X _2359_/X _2360_/X VGND VGND VPWR VPWR _2361_/X sky130_fd_sc_hd__a211o_1
X_2292_ _3215_/Q _2576_/B _2291_/X _3259_/Q _2552_/A VGND VGND VPWR VPWR _2292_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_2_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2628_ _2384_/C _2335_/A _2075_/B _2668_/C VGND VGND VPWR VPWR _2628_/X sky130_fd_sc_hd__o31a_1
X_2559_ input19/X _3232_/Q _2574_/S VGND VGND VPWR VPWR _3232_/D sky130_fd_sc_hd__mux2_1
XFILLER_28_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1930_ _3157_/Q _1929_/X _1932_/S VGND VGND VPWR VPWR _3157_/D sky130_fd_sc_hd__mux2_1
X_1861_ _1861_/A VGND VGND VPWR VPWR _2740_/C sky130_fd_sc_hd__buf_8
Xinput22 i_wb_addr[7] VGND VGND VPWR VPWR input22/X sky130_fd_sc_hd__clkbuf_2
Xinput11 i_wb_addr[15] VGND VGND VPWR VPWR _1804_/B sky130_fd_sc_hd__buf_2
XFILLER_52_90 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput55 i_wb_data[6] VGND VGND VPWR VPWR input55/X sky130_fd_sc_hd__clkbuf_1
Xinput33 i_wb_data[15] VGND VGND VPWR VPWR input33/X sky130_fd_sc_hd__clkbuf_1
X_1792_ _3244_/Q _3245_/Q VGND VGND VPWR VPWR _1793_/B sky130_fd_sc_hd__nand2_1
Xinput44 i_wb_data[25] VGND VGND VPWR VPWR input44/X sky130_fd_sc_hd__clkbuf_1
X_3393_ _3397_/CLK _3393_/D VGND VGND VPWR VPWR _3393_/Q sky130_fd_sc_hd__dfxtp_1
X_2413_ _1608_/X _2393_/X _2406_/X _2412_/X _2247_/D VGND VGND VPWR VPWR _2413_/X
+ sky130_fd_sc_hd__a311o_1
X_2344_ _2384_/C _2335_/A _2616_/C _2247_/D VGND VGND VPWR VPWR _2344_/X sky130_fd_sc_hd__a31o_1
X_2275_ _3186_/Q _2162_/X _2164_/X input22/X _2274_/X VGND VGND VPWR VPWR _2275_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_37_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_242 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2060_ _2048_/Y _2051_/X _2059_/X VGND VGND VPWR VPWR _3166_/D sky130_fd_sc_hd__a21oi_1
XFILLER_19_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2962_ _3179_/Q _2907_/X _2909_/X _2961_/X VGND VGND VPWR VPWR _2962_/X sky130_fd_sc_hd__o211a_1
X_1913_ _3148_/Q _3145_/Q _2884_/S VGND VGND VPWR VPWR _1913_/X sky130_fd_sc_hd__mux2_1
X_2893_ _3406_/Q _3402_/Q _2892_/X VGND VGND VPWR VPWR _2893_/X sky130_fd_sc_hd__a21bo_1
X_1844_ _2576_/C _1844_/B _2668_/C _2851_/A VGND VGND VPWR VPWR _1844_/X sky130_fd_sc_hd__and4b_1
X_1775_ _1810_/B _1810_/C _1774_/D _3238_/Q VGND VGND VPWR VPWR _2008_/B sky130_fd_sc_hd__a31o_1
X_3376_ _3397_/CLK _3376_/D VGND VGND VPWR VPWR _3376_/Q sky130_fd_sc_hd__dfxtp_1
X_2327_ _3191_/Q _2162_/X _2164_/X input8/X _2326_/X VGND VGND VPWR VPWR _2327_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_57_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_315 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2258_ _2448_/A _2424_/A _2434_/B VGND VGND VPWR VPWR _2259_/A sky130_fd_sc_hd__or3b_1
X_2189_ _2368_/B _2368_/C _2658_/B VGND VGND VPWR VPWR _2190_/D sky130_fd_sc_hd__a21oi_1
XFILLER_48_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_462 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3230_ _3330_/CLK _3230_/D VGND VGND VPWR VPWR _3230_/Q sky130_fd_sc_hd__dfxtp_2
XTAP_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3161_ _3366_/CLK _3161_/D VGND VGND VPWR VPWR _3161_/Q sky130_fd_sc_hd__dfxtp_1
X_2112_ _2626_/B _2112_/B _2112_/C VGND VGND VPWR VPWR _2128_/C sky130_fd_sc_hd__and3_1
X_3092_ _3084_/S _3093_/B _3402_/Q VGND VGND VPWR VPWR _3097_/B sky130_fd_sc_hd__o21bai_2
XFILLER_66_178 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2043_ _2726_/A _2043_/B _2740_/A _2324_/D VGND VGND VPWR VPWR _2044_/A sky130_fd_sc_hd__or4_1
XFILLER_22_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2945_ _3376_/Q _2906_/X _2944_/X VGND VGND VPWR VPWR _3376_/D sky130_fd_sc_hd__a21o_1
X_2876_ _3357_/Q _1927_/X _3331_/D VGND VGND VPWR VPWR _3357_/D sky130_fd_sc_hd__mux2_1
XFILLER_30_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1827_ _1827_/A _1827_/B _1827_/C _1827_/D VGND VGND VPWR VPWR _2612_/C sky130_fd_sc_hd__nand4_4
X_1758_ _2585_/A _2368_/B _3230_/Q VGND VGND VPWR VPWR _1758_/Y sky130_fd_sc_hd__a21oi_1
X_1689_ _2448_/A _2324_/D VGND VGND VPWR VPWR _2492_/B sky130_fd_sc_hd__nor2_2
X_3359_ _3363_/CLK _3359_/D VGND VGND VPWR VPWR _3359_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_2_1__f_i_clk clkbuf_0_i_clk/X VGND VGND VPWR VPWR _3288_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_80_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_1_i_clk clkbuf_leaf_1_i_clk/A VGND VGND VPWR VPWR _3278_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_21_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_436 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_340 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2730_ _1661_/X _2648_/X _2052_/X _2729_/X _3122_/A VGND VGND VPWR VPWR _2730_/X
+ sky130_fd_sc_hd__a2111o_1
XFILLER_12_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2661_ _2657_/X _2660_/X _2442_/Y VGND VGND VPWR VPWR _2661_/Y sky130_fd_sc_hd__a21boi_1
XFILLER_8_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1612_ _1851_/C _2043_/B VGND VGND VPWR VPWR _2577_/D sky130_fd_sc_hd__nand2_8
X_2592_ _1692_/Y _2612_/C _2591_/Y VGND VGND VPWR VPWR _2592_/Y sky130_fd_sc_hd__o21bai_1
X_3213_ _3278_/CLK _3213_/D VGND VGND VPWR VPWR _3213_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_39_123 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3144_ _3345_/CLK _3144_/D VGND VGND VPWR VPWR _3144_/Q sky130_fd_sc_hd__dfxtp_1
X_3075_ _3072_/X _2826_/X _2922_/A _3074_/X VGND VGND VPWR VPWR _3075_/X sky130_fd_sc_hd__a211o_1
XFILLER_67_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2026_ _2026_/A _2026_/B _2026_/C _2026_/D VGND VGND VPWR VPWR _2035_/C sky130_fd_sc_hd__nor4_1
XFILLER_62_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2928_ _3373_/Q _3370_/Q _3093_/A VGND VGND VPWR VPWR _2928_/X sky130_fd_sc_hd__mux2_1
XFILLER_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2859_ _3340_/Q _1893_/X _3331_/D VGND VGND VPWR VPWR _3340_/D sky130_fd_sc_hd__mux2_1
XFILLER_58_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_351 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_107 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_229 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_80 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput9 i_wb_addr[13] VGND VGND VPWR VPWR input9/X sky130_fd_sc_hd__clkbuf_4
XFILLER_17_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2713_ _3275_/Q input37/X _2717_/S VGND VGND VPWR VPWR _3275_/D sky130_fd_sc_hd__mux2_1
X_2644_ _2739_/A _2644_/B _2644_/C _2644_/D VGND VGND VPWR VPWR _2644_/X sky130_fd_sc_hd__and4b_1
X_2575_ _3257_/Q _3335_/Q _2575_/S VGND VGND VPWR VPWR _2575_/X sky130_fd_sc_hd__mux2_1
X_3127_ _3408_/Q _3124_/Y _3126_/X _2078_/X VGND VGND VPWR VPWR _3408_/D sky130_fd_sc_hd__o211a_1
XFILLER_55_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3058_ _3195_/Q _2907_/X _2909_/X _3057_/X VGND VGND VPWR VPWR _3058_/X sky130_fd_sc_hd__o211a_1
XFILLER_42_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_192 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2009_ input8/X _2007_/Y input6/X _2008_/Y VGND VGND VPWR VPWR _2009_/X sky130_fd_sc_hd__a2bb2o_1
XFILLER_63_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_240 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2360_ _1679_/B _3195_/Q _1987_/Y _1854_/Y _2520_/B VGND VGND VPWR VPWR _2360_/X
+ sky130_fd_sc_hd__o311a_1
X_2291_ _2313_/C _2594_/B _2384_/C VGND VGND VPWR VPWR _2291_/X sky130_fd_sc_hd__and3_2
XFILLER_2_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2627_ _2120_/C _2051_/B _2622_/X _2623_/X _2626_/Y VGND VGND VPWR VPWR _2637_/C
+ sky130_fd_sc_hd__a2111oi_1
X_2558_ _1720_/B _3231_/Q _2574_/S VGND VGND VPWR VPWR _3231_/D sky130_fd_sc_hd__mux2_1
X_2489_ _2483_/Y _2484_/X _2485_/X _2486_/Y _2488_/X VGND VGND VPWR VPWR _2489_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_28_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_48 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1860_ _3255_/Q _2424_/A _2434_/B _1860_/D VGND VGND VPWR VPWR _1861_/A sky130_fd_sc_hd__or4_1
X_1791_ _1791_/A _1791_/B input7/X VGND VGND VPWR VPWR _1791_/Y sky130_fd_sc_hd__nand3_1
Xinput12 i_wb_addr[16] VGND VGND VPWR VPWR input12/X sky130_fd_sc_hd__clkbuf_2
Xinput23 i_wb_addr[8] VGND VGND VPWR VPWR input23/X sky130_fd_sc_hd__clkbuf_2
Xinput34 i_wb_data[16] VGND VGND VPWR VPWR input34/X sky130_fd_sc_hd__clkbuf_1
Xinput45 i_wb_data[26] VGND VGND VPWR VPWR input45/X sky130_fd_sc_hd__clkbuf_1
Xinput56 i_wb_data[7] VGND VGND VPWR VPWR input56/X sky130_fd_sc_hd__clkbuf_1
X_3392_ _3397_/CLK _3392_/D VGND VGND VPWR VPWR _3392_/Q sky130_fd_sc_hd__dfxtp_1
X_2412_ _2726_/B _2407_/X _2410_/X _2419_/B VGND VGND VPWR VPWR _2412_/X sky130_fd_sc_hd__o22a_1
XFILLER_42_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2343_ _2740_/C _2335_/X _2336_/X _2342_/X VGND VGND VPWR VPWR _2343_/X sky130_fd_sc_hd__o22a_1
X_2274_ _3235_/Q _2577_/D _2120_/B _2273_/X VGND VGND VPWR VPWR _2274_/X sky130_fd_sc_hd__o31a_1
XFILLER_37_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1989_ _1872_/D _1988_/X _2091_/C VGND VGND VPWR VPWR _1989_/X sky130_fd_sc_hd__o21a_1
XFILLER_4_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2961_ _2958_/X _2826_/X _3100_/A _2960_/X VGND VGND VPWR VPWR _2961_/X sky130_fd_sc_hd__a211o_1
XFILLER_22_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1912_ _3148_/Q _1911_/X _1932_/S VGND VGND VPWR VPWR _3148_/D sky130_fd_sc_hd__mux2_1
X_2892_ _3406_/Q _3402_/Q _3084_/S VGND VGND VPWR VPWR _2892_/X sky130_fd_sc_hd__mux2_1
X_1843_ _2424_/A _2434_/B _2114_/D _2448_/A VGND VGND VPWR VPWR _2668_/C sky130_fd_sc_hd__or4_1
X_1774_ _3238_/Q _1810_/B _1810_/C _1774_/D VGND VGND VPWR VPWR _2008_/A sky130_fd_sc_hd__nand4_1
X_3375_ _3397_/CLK _3375_/D VGND VGND VPWR VPWR _3375_/Q sky130_fd_sc_hd__dfxtp_1
X_2326_ _3278_/Q _1844_/B _2741_/C _3240_/Q _2325_/X VGND VGND VPWR VPWR _2326_/X
+ sky130_fd_sc_hd__o221a_1
XFILLER_57_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_176 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2257_ _2436_/C _2492_/A _2190_/D _2552_/C VGND VGND VPWR VPWR _2257_/X sky130_fd_sc_hd__a31o_1
XFILLER_27_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_202 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2188_ _2188_/A _2188_/B VGND VGND VPWR VPWR _2368_/C sky130_fd_sc_hd__nor2_4
XFILLER_65_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_378 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_316 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3160_ _3365_/CLK _3160_/D VGND VGND VPWR VPWR _3160_/Q sky130_fd_sc_hd__dfxtp_1
X_3091_ _3406_/Q _3407_/Q VGND VGND VPWR VPWR _3093_/B sky130_fd_sc_hd__nor2_1
X_2111_ _2644_/D _2740_/B _1626_/X _1683_/X _2001_/X VGND VGND VPWR VPWR _2112_/C
+ sky130_fd_sc_hd__o32a_1
X_2042_ _2097_/A _2658_/C _2188_/A _1679_/B VGND VGND VPWR VPWR _2042_/X sky130_fd_sc_hd__a31o_1
XFILLER_66_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2944_ _3176_/Q _2907_/X _2909_/X _2943_/X VGND VGND VPWR VPWR _2944_/X sky130_fd_sc_hd__o211a_1
X_2875_ _3356_/Q _1925_/X _3331_/D VGND VGND VPWR VPWR _3356_/D sky130_fd_sc_hd__mux2_1
X_1826_ _1803_/Y _1804_/Y _1807_/X _1808_/Y _1825_/Y VGND VGND VPWR VPWR _1827_/D
+ sky130_fd_sc_hd__a221oi_4
X_1757_ _3230_/Q _1740_/B input17/X VGND VGND VPWR VPWR _1757_/Y sky130_fd_sc_hd__o21ai_1
X_1688_ _1688_/A VGND VGND VPWR VPWR _2324_/D sky130_fd_sc_hd__buf_6
X_3358_ _3363_/CLK _3358_/D VGND VGND VPWR VPWR _3358_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_38_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2309_ _2733_/A _2090_/X _2308_/X _2247_/D VGND VGND VPWR VPWR _2309_/X sky130_fd_sc_hd__a31o_1
XFILLER_57_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3289_ _3289_/CLK _3289_/D VGND VGND VPWR VPWR _3289_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_38_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_89 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_352 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_7 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2660_ _2658_/X _2659_/X _2044_/X _1626_/X VGND VGND VPWR VPWR _2660_/X sky130_fd_sc_hd__o31a_1
X_1611_ _3203_/Q _2739_/C VGND VGND VPWR VPWR _1611_/Y sky130_fd_sc_hd__nor2_1
XFILLER_60_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2591_ _2335_/A _2456_/D _2492_/C _2612_/D VGND VGND VPWR VPWR _2591_/Y sky130_fd_sc_hd__a211oi_1
XFILLER_5_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3212_ _3278_/CLK _3212_/D VGND VGND VPWR VPWR _3212_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_67_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_135 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3143_ _3345_/CLK _3143_/D VGND VGND VPWR VPWR _3143_/Q sky130_fd_sc_hd__dfxtp_1
X_3074_ _2832_/A _3194_/Q _3073_/X _2816_/A VGND VGND VPWR VPWR _3074_/X sky130_fd_sc_hd__o211a_1
X_2025_ _2023_/Y _2025_/B _2025_/C _2025_/D VGND VGND VPWR VPWR _2026_/D sky130_fd_sc_hd__nand4b_1
XFILLER_24_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2927_ _3373_/Q _2906_/X _2926_/X VGND VGND VPWR VPWR _3373_/D sky130_fd_sc_hd__a21o_1
X_2858_ _3339_/Q _1891_/X _3331_/D VGND VGND VPWR VPWR _3339_/D sky130_fd_sc_hd__mux2_1
X_2789_ _3354_/Q _2888_/S _2801_/C VGND VGND VPWR VPWR _2789_/X sky130_fd_sc_hd__and3_1
X_1809_ _1815_/B _1815_/C _1809_/C VGND VGND VPWR VPWR _1809_/Y sky130_fd_sc_hd__nor3_1
XFILLER_58_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_119 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_411 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_92 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2712_ _3274_/Q input36/X _2717_/S VGND VGND VPWR VPWR _3274_/D sky130_fd_sc_hd__mux2_1
XFILLER_71_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2643_ _2643_/A _2643_/B VGND VGND VPWR VPWR _3251_/D sky130_fd_sc_hd__nand2_1
X_2574_ _1808_/B _3247_/Q _2574_/S VGND VGND VPWR VPWR _3247_/D sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_0_i_clk clkbuf_leaf_1_i_clk/A VGND VGND VPWR VPWR _3409_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_82_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3126_ _3339_/Q _2110_/C _2291_/X _3261_/Q _3125_/X VGND VGND VPWR VPWR _3126_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_27_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3057_ _3054_/X _2826_/X _3100_/A _3056_/X VGND VGND VPWR VPWR _3057_/X sky130_fd_sc_hd__a211o_1
X_2008_ _2008_/A _2008_/B VGND VGND VPWR VPWR _2008_/Y sky130_fd_sc_hd__nand2_1
XFILLER_18_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2290_ _3273_/Q _2616_/D _2313_/C VGND VGND VPWR VPWR _2290_/X sky130_fd_sc_hd__and3_2
XFILLER_1_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_222 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_370 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput100 _3308_/Q VGND VGND VPWR VPWR o_wb_data[7] sky130_fd_sc_hd__clkbuf_1
X_2626_ _2625_/X _2626_/B _2626_/C _2626_/D VGND VGND VPWR VPWR _2626_/Y sky130_fd_sc_hd__nand4b_1
X_2557_ input17/X _3230_/Q _2574_/S VGND VGND VPWR VPWR _3230_/D sky130_fd_sc_hd__mux2_1
X_2488_ _2478_/B _3205_/Q _2479_/Y _3244_/Q _2487_/X VGND VGND VPWR VPWR _2488_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_55_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3109_ _3202_/Q _3201_/Q _3100_/A _3108_/X VGND VGND VPWR VPWR _3109_/Y sky130_fd_sc_hd__a31oi_1
XFILLER_23_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1790_ _1810_/B _1810_/C _1787_/X _3239_/Q VGND VGND VPWR VPWR _1791_/B sky130_fd_sc_hd__a31o_1
Xinput13 i_wb_addr[17] VGND VGND VPWR VPWR input13/X sky130_fd_sc_hd__buf_2
Xinput24 i_wb_addr[9] VGND VGND VPWR VPWR _1821_/B sky130_fd_sc_hd__clkbuf_2
Xinput35 i_wb_data[17] VGND VGND VPWR VPWR input35/X sky130_fd_sc_hd__clkbuf_1
Xinput46 i_wb_data[27] VGND VGND VPWR VPWR input46/X sky130_fd_sc_hd__clkbuf_1
Xinput57 i_wb_data[8] VGND VGND VPWR VPWR input57/X sky130_fd_sc_hd__clkbuf_1
X_3391_ _3391_/CLK _3391_/D VGND VGND VPWR VPWR _3391_/Q sky130_fd_sc_hd__dfxtp_1
X_2411_ _2520_/C _2411_/B _2520_/B _2726_/C VGND VGND VPWR VPWR _2419_/B sky130_fd_sc_hd__and4_1
X_2342_ _3242_/Q _2577_/D _2120_/B _2341_/X VGND VGND VPWR VPWR _2342_/X sky130_fd_sc_hd__o31a_1
XFILLER_69_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2273_ _2520_/C _1644_/X _2257_/X _3243_/Q _2272_/X VGND VGND VPWR VPWR _2273_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_77_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1988_ _2739_/C _1987_/Y _1866_/Y VGND VGND VPWR VPWR _1988_/X sky130_fd_sc_hd__o21ba_1
X_2609_ _1986_/Y _2431_/X _1608_/X VGND VGND VPWR VPWR _2609_/Y sky130_fd_sc_hd__a21boi_1
XFILLER_16_439 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2960_ _2832_/A _3175_/Q _2959_/X _2816_/X VGND VGND VPWR VPWR _2960_/X sky130_fd_sc_hd__o211a_1
X_2891_ _3407_/Q _3403_/Q _3405_/Q _3404_/Q VGND VGND VPWR VPWR _2891_/X sky130_fd_sc_hd__or4_1
X_1911_ _3147_/Q _3144_/Q _2884_/S VGND VGND VPWR VPWR _1911_/X sky130_fd_sc_hd__mux2_1
X_1842_ _2448_/A _2384_/C _2740_/A _2324_/D VGND VGND VPWR VPWR _1844_/B sky130_fd_sc_hd__or4_4
XFILLER_30_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1773_ _3236_/Q _3237_/Q VGND VGND VPWR VPWR _1774_/D sky130_fd_sc_hd__and2_1
XFILLER_6_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3374_ _3397_/CLK _3374_/D VGND VGND VPWR VPWR _3374_/Q sky130_fd_sc_hd__dfxtp_1
X_2325_ _3409_/Q _2576_/B _2291_/X _3262_/Q _1644_/X VGND VGND VPWR VPWR _2325_/X
+ sky130_fd_sc_hd__a221o_1
X_2256_ _3184_/Q _2129_/X _2252_/X _2255_/X VGND VGND VPWR VPWR _3184_/D sky130_fd_sc_hd__o22a_1
XFILLER_69_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2187_ _2448_/A _2448_/B _2324_/D VGND VGND VPWR VPWR _2187_/X sky130_fd_sc_hd__or3_4
XFILLER_65_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_206 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3090_ _3169_/Q _2896_/C _2838_/B _2906_/A _3401_/Q VGND VGND VPWR VPWR _3401_/D
+ sky130_fd_sc_hd__a32o_1
X_2110_ _2496_/A _2613_/B _2110_/C _3123_/B VGND VGND VPWR VPWR _2128_/B sky130_fd_sc_hd__or4_2
XFILLER_54_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2041_ _2086_/B VGND VGND VPWR VPWR _2658_/C sky130_fd_sc_hd__clkinv_2
XFILLER_62_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2943_ _2940_/X _2826_/X _3100_/A _2942_/X VGND VGND VPWR VPWR _2943_/X sky130_fd_sc_hd__a211o_1
XFILLER_22_217 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_397 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2874_ _3355_/Q _1923_/X _3331_/D VGND VGND VPWR VPWR _3355_/D sky130_fd_sc_hd__mux2_1
X_1825_ _1811_/X _1813_/Y _1816_/Y _1819_/Y _2025_/D VGND VGND VPWR VPWR _1825_/Y
+ sky130_fd_sc_hd__o2111ai_4
X_1756_ _2585_/A _2368_/B _3230_/Q VGND VGND VPWR VPWR _1756_/X sky130_fd_sc_hd__and3_1
X_1687_ _3254_/Q _3253_/Q VGND VGND VPWR VPWR _1688_/A sky130_fd_sc_hd__or2b_1
X_3357_ _3363_/CLK _3357_/D VGND VGND VPWR VPWR _3357_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2308_ _2389_/C _1772_/B _2307_/X VGND VGND VPWR VPWR _2308_/X sky130_fd_sc_hd__o21a_1
XFILLER_57_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3288_ _3288_/CLK _3288_/D VGND VGND VPWR VPWR _3288_/Q sky130_fd_sc_hd__dfxtp_2
XFILLER_57_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2239_ _2733_/A _2090_/X _2238_/X _2247_/D VGND VGND VPWR VPWR _2239_/X sky130_fd_sc_hd__a31o_1
XFILLER_38_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1610_ _1610_/A VGND VGND VPWR VPWR _2739_/C sky130_fd_sc_hd__buf_2
XFILLER_67_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2590_ _2341_/B _2188_/B _3248_/Q _1873_/B _2492_/A VGND VGND VPWR VPWR _2590_/X
+ sky130_fd_sc_hd__a32o_1
X_3211_ _3356_/CLK _3211_/D VGND VGND VPWR VPWR _3211_/Q sky130_fd_sc_hd__dfxtp_1
X_3142_ _3345_/CLK _3142_/D VGND VGND VPWR VPWR _3142_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_39_147 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3073_ _3167_/Q _3197_/Q VGND VGND VPWR VPWR _3073_/X sky130_fd_sc_hd__or2_1
XFILLER_39_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2024_ _1810_/B _1810_/C _1729_/A _1738_/Y input22/X VGND VGND VPWR VPWR _2025_/C
+ sky130_fd_sc_hd__a221o_1
X_2926_ _3173_/Q _2907_/X _2909_/X _2925_/X VGND VGND VPWR VPWR _2926_/X sky130_fd_sc_hd__o211a_1
X_2857_ _3338_/Q _1889_/X _3331_/D VGND VGND VPWR VPWR _3338_/D sky130_fd_sc_hd__mux2_1
XFILLER_40_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1808_ _2012_/C _1808_/B _2012_/B VGND VGND VPWR VPWR _1808_/Y sky130_fd_sc_hd__nand3_1
X_2788_ _3314_/Q _2747_/X _2787_/X VGND VGND VPWR VPWR _3314_/D sky130_fd_sc_hd__a21o_1
X_1739_ _1727_/Y _1815_/B _1695_/Y _1738_/Y VGND VGND VPWR VPWR _1739_/X sky130_fd_sc_hd__o31a_1
XFILLER_49_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3409_ _3409_/CLK _3409_/D VGND VGND VPWR VPWR _3409_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_220 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2711_ _3273_/Q input35/X _2717_/S VGND VGND VPWR VPWR _3273_/D sky130_fd_sc_hd__mux2_1
X_2642_ _2318_/A _2411_/B _2726_/B _2594_/B _2641_/Y VGND VGND VPWR VPWR _2643_/B
+ sky130_fd_sc_hd__o32a_1
XFILLER_65_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2573_ _1772_/B _3246_/Q _2574_/S VGND VGND VPWR VPWR _3246_/D sky130_fd_sc_hd__mux2_1
XFILLER_67_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3125_ _3125_/A _3125_/B _3125_/C VGND VGND VPWR VPWR _3125_/X sky130_fd_sc_hd__or3_1
X_3056_ _2832_/A _3191_/Q _3055_/X _2816_/X VGND VGND VPWR VPWR _3056_/X sky130_fd_sc_hd__o211a_1
X_2007_ _3240_/Q _1809_/Y _1810_/Y VGND VGND VPWR VPWR _2007_/Y sky130_fd_sc_hd__o21ai_1
X_2909_ _2909_/A VGND VGND VPWR VPWR _2909_/X sky130_fd_sc_hd__buf_8
XFILLER_76_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_404 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_256 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput101 _3309_/Q VGND VGND VPWR VPWR o_wb_data[8] sky130_fd_sc_hd__clkbuf_1
X_2625_ _2460_/X _2492_/C _2624_/X _2851_/B _1992_/X VGND VGND VPWR VPWR _2625_/X
+ sky130_fd_sc_hd__a221o_1
X_2556_ _2604_/A _2368_/B _2574_/S VGND VGND VPWR VPWR _3229_/D sky130_fd_sc_hd__mux2_1
X_2487_ _2480_/Y _3206_/Q _3208_/Q _1766_/B VGND VGND VPWR VPWR _2487_/X sky130_fd_sc_hd__a22o_1
X_3108_ _3405_/Q _3404_/Q _3108_/C _3108_/D VGND VGND VPWR VPWR _3108_/X sky130_fd_sc_hd__and4bb_1
XFILLER_55_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3039_ _3036_/X _2826_/X _3100_/A _3038_/X VGND VGND VPWR VPWR _3039_/X sky130_fd_sc_hd__a211o_1
XFILLER_43_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_304 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput25 i_wb_ctrl_stb VGND VGND VPWR VPWR _1616_/A sky130_fd_sc_hd__clkbuf_1
Xinput36 i_wb_data[18] VGND VGND VPWR VPWR input36/X sky130_fd_sc_hd__clkbuf_1
Xinput14 i_wb_addr[18] VGND VGND VPWR VPWR _1772_/B sky130_fd_sc_hd__buf_2
Xinput47 i_wb_data[28] VGND VGND VPWR VPWR input47/X sky130_fd_sc_hd__clkbuf_2
XFILLER_6_352 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput58 i_wb_data[9] VGND VGND VPWR VPWR input58/X sky130_fd_sc_hd__clkbuf_1
X_2410_ _3248_/Q _2577_/D _2004_/B _2190_/X _2409_/X VGND VGND VPWR VPWR _2410_/X
+ sky130_fd_sc_hd__o311a_1
X_3390_ _3391_/CLK _3390_/D VGND VGND VPWR VPWR _3390_/Q sky130_fd_sc_hd__dfxtp_1
X_2341_ _2456_/B _2341_/B _2341_/C _2341_/D VGND VGND VPWR VPWR _2341_/X sky130_fd_sc_hd__or4_1
X_2272_ _3273_/Q _2577_/D _2547_/C _2271_/X VGND VGND VPWR VPWR _2272_/X sky130_fd_sc_hd__o31a_1
XFILLER_69_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1987_ _3203_/Q _2086_/B VGND VGND VPWR VPWR _1987_/Y sky130_fd_sc_hd__nor2_2
XFILLER_9_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2608_ _2441_/A _2644_/C _2644_/D VGND VGND VPWR VPWR _2608_/Y sky130_fd_sc_hd__nand3b_1
X_2539_ _2692_/A _2539_/B _2538_/X VGND VGND VPWR VPWR _3225_/D sky130_fd_sc_hd__or3b_1
XFILLER_28_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_259 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2890_ _2048_/Y _2838_/A _2827_/B _2889_/Y _1567_/X VGND VGND VPWR VPWR _2890_/Y
+ sky130_fd_sc_hd__a32oi_1
XFILLER_42_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1910_ _3147_/Q _1909_/X _1932_/S VGND VGND VPWR VPWR _3147_/D sky130_fd_sc_hd__mux2_1
XFILLER_30_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1841_ _2114_/D _2726_/B _2492_/A _2496_/A VGND VGND VPWR VPWR _2576_/C sky130_fd_sc_hd__a31o_1
XFILLER_8_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1772_ _2027_/B _1772_/B _2027_/A VGND VGND VPWR VPWR _1772_/X sky130_fd_sc_hd__and3_1
XFILLER_6_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3373_ _3397_/CLK _3373_/D VGND VGND VPWR VPWR _3373_/Q sky130_fd_sc_hd__dfxtp_1
X_2324_ _2726_/A _2384_/C _2740_/A _2324_/D VGND VGND VPWR VPWR _2741_/C sky130_fd_sc_hd__or4_4
XFILLER_69_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2255_ _2733_/A _2090_/X _2254_/X _2247_/D VGND VGND VPWR VPWR _2255_/X sky130_fd_sc_hd__a31o_1
X_2186_ _2185_/X _3176_/Q _2247_/D VGND VGND VPWR VPWR _3176_/D sky130_fd_sc_hd__mux2_1
XFILLER_80_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_376 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2040_ _2188_/B _2040_/B VGND VGND VPWR VPWR _2040_/X sky130_fd_sc_hd__or2_1
Xclkbuf_leaf_32_i_clk clkbuf_leaf_1_i_clk/A VGND VGND VPWR VPWR _3266_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_62_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2942_ _2832_/A _3172_/Q _2941_/X _2816_/X VGND VGND VPWR VPWR _2942_/X sky130_fd_sc_hd__o211a_1
XFILLER_22_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2873_ _3354_/Q _1921_/X _3331_/D VGND VGND VPWR VPWR _3354_/D sky130_fd_sc_hd__mux2_1
X_1824_ _1778_/Y _1821_/Y _1823_/Y VGND VGND VPWR VPWR _2025_/D sky130_fd_sc_hd__o21ai_2
X_1755_ input5/X _2585_/A VGND VGND VPWR VPWR _2018_/C sky130_fd_sc_hd__xor2_1
X_1686_ _2726_/A _2384_/C _2448_/D VGND VGND VPWR VPWR _2741_/B sky130_fd_sc_hd__or3_4
X_3356_ _3356_/CLK _3356_/D VGND VGND VPWR VPWR _3356_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2307_ _2389_/A _3189_/Q _2441_/A VGND VGND VPWR VPWR _2307_/X sky130_fd_sc_hd__a21bo_1
XFILLER_38_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3287_ _3287_/CLK _3287_/D VGND VGND VPWR VPWR _3287_/Q sky130_fd_sc_hd__dfxtp_2
XTAP_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2238_ _2389_/C input7/X _2237_/X VGND VGND VPWR VPWR _2238_/X sky130_fd_sc_hd__o21a_1
XTAP_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2169_ _2436_/C _1854_/Y _2167_/X _2168_/X VGND VGND VPWR VPWR _2169_/X sky130_fd_sc_hd__a22o_1
XFILLER_65_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_192 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_104 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3210_ _3353_/CLK _3210_/D VGND VGND VPWR VPWR _3210_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_39_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_402 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3141_ _3345_/CLK _3141_/D VGND VGND VPWR VPWR _3141_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_10_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3072_ _3397_/Q _3394_/Q _3084_/S VGND VGND VPWR VPWR _3072_/X sky130_fd_sc_hd__mux2_1
X_2023_ _2023_/A _2023_/B VGND VGND VPWR VPWR _2023_/Y sky130_fd_sc_hd__nand2_1
XFILLER_50_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2925_ _2921_/X _2826_/X _3100_/A _2924_/X VGND VGND VPWR VPWR _2925_/X sky130_fd_sc_hd__a211o_1
X_2856_ _3337_/Q _1887_/X _3331_/D VGND VGND VPWR VPWR _3337_/D sky130_fd_sc_hd__mux2_1
XFILLER_40_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1807_ _2012_/B _2012_/C _1808_/B VGND VGND VPWR VPWR _1807_/X sky130_fd_sc_hd__a21o_1
X_2787_ _3347_/Q _2888_/S _2801_/C VGND VGND VPWR VPWR _2787_/X sky130_fd_sc_hd__and3_1
X_1738_ _3235_/Q VGND VGND VPWR VPWR _1738_/Y sky130_fd_sc_hd__inv_2
X_1669_ _1657_/X _1661_/X _1665_/X _1668_/X _3288_/Q VGND VGND VPWR VPWR _1669_/X
+ sky130_fd_sc_hd__o311a_1
X_3408_ _3409_/CLK _3408_/D VGND VGND VPWR VPWR _3408_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_49_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3339_ _3343_/CLK _3339_/D VGND VGND VPWR VPWR _3339_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_232 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_276 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_460 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2710_ _3272_/Q input34/X _2717_/S VGND VGND VPWR VPWR _3272_/D sky130_fd_sc_hd__mux2_1
X_2641_ _2641_/A _2641_/B VGND VGND VPWR VPWR _2641_/Y sky130_fd_sc_hd__nor2_2
XFILLER_58_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2572_ input13/X _3245_/Q _2574_/S VGND VGND VPWR VPWR _3245_/D sky130_fd_sc_hd__mux2_1
XFILLER_67_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3124_ _3125_/A _3125_/B _3125_/C VGND VGND VPWR VPWR _3124_/Y sky130_fd_sc_hd__nor3_1
X_3055_ _3055_/A _3194_/Q VGND VGND VPWR VPWR _3055_/X sky130_fd_sc_hd__or2_1
XFILLER_48_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2006_ _2448_/B _2335_/A _1661_/A _2005_/X VGND VGND VPWR VPWR _2039_/A sky130_fd_sc_hd__a31o_1
XFILLER_35_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_379 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2908_ _2889_/B _1573_/B _2896_/C _2896_/X _2818_/Y VGND VGND VPWR VPWR _2909_/A
+ sky130_fd_sc_hd__a311oi_4
X_2839_ _2851_/C _2907_/A _2816_/X _2895_/B VGND VGND VPWR VPWR _2839_/X sky130_fd_sc_hd__a31o_1
XFILLER_2_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_268 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2624_ _2448_/B _2594_/B _2492_/B _3122_/B VGND VGND VPWR VPWR _2624_/X sky130_fd_sc_hd__a31o_1
Xoutput102 _3310_/Q VGND VGND VPWR VPWR o_wb_data[9] sky130_fd_sc_hd__clkbuf_1
X_2555_ input5/X _2585_/A _2574_/S VGND VGND VPWR VPWR _3228_/D sky130_fd_sc_hd__mux2_1
X_2486_ _3246_/Q _3209_/Q VGND VGND VPWR VPWR _2486_/Y sky130_fd_sc_hd__nand2_1
X_3107_ _3105_/Y _3106_/X _3404_/Q _3101_/S VGND VGND VPWR VPWR _3404_/D sky130_fd_sc_hd__a2bb2o_1
XFILLER_46_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3038_ _2832_/A _3188_/Q _3037_/X _2816_/X VGND VGND VPWR VPWR _3038_/X sky130_fd_sc_hd__o211a_1
XFILLER_55_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_50 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput26 i_wb_cyc VGND VGND VPWR VPWR _2612_/B sky130_fd_sc_hd__buf_4
Xinput37 i_wb_data[19] VGND VGND VPWR VPWR input37/X sky130_fd_sc_hd__clkbuf_1
Xinput15 i_wb_addr[19] VGND VGND VPWR VPWR _1808_/B sky130_fd_sc_hd__buf_2
Xinput59 i_wb_data_stb VGND VGND VPWR VPWR _2740_/B sky130_fd_sc_hd__buf_4
Xinput48 i_wb_data[29] VGND VGND VPWR VPWR input48/X sky130_fd_sc_hd__clkbuf_1
XFILLER_6_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2340_ _3280_/Q _1844_/B _2339_/X VGND VGND VPWR VPWR _2341_/D sky130_fd_sc_hd__o21ba_1
X_2271_ _3271_/Q _2109_/A _2552_/A _2270_/X VGND VGND VPWR VPWR _2271_/X sky130_fd_sc_hd__a211o_1
XFILLER_77_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_271 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1986_ _2441_/A _2086_/B _3203_/Q VGND VGND VPWR VPWR _1986_/Y sky130_fd_sc_hd__a21oi_1
X_2607_ _2644_/C _2606_/X _2630_/B VGND VGND VPWR VPWR _2607_/X sky130_fd_sc_hd__a21o_1
X_2538_ _3225_/Q _2543_/C _2543_/D _1983_/X VGND VGND VPWR VPWR _2538_/X sky130_fd_sc_hd__or4b_1
X_2469_ _2335_/A input47/X _2740_/C _2468_/X _2467_/Y VGND VGND VPWR VPWR _2469_/X
+ sky130_fd_sc_hd__o311a_1
XFILLER_16_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_371 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1840_ _2726_/A _2520_/A _2520_/B _2575_/S VGND VGND VPWR VPWR _2496_/A sky130_fd_sc_hd__a31o_1
XFILLER_42_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_66 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1771_ _2027_/A _2027_/B _1772_/B VGND VGND VPWR VPWR _1771_/Y sky130_fd_sc_hd__a21oi_1
X_3372_ _3407_/CLK _3372_/D VGND VGND VPWR VPWR _3372_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_40_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2323_ _3190_/Q _2129_/X _2319_/X _2322_/X VGND VGND VPWR VPWR _3190_/D sky130_fd_sc_hd__o22a_1
XFILLER_69_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2254_ _2389_/C input9/X _2253_/X VGND VGND VPWR VPWR _2254_/X sky130_fd_sc_hd__o21a_1
X_2185_ _3176_/Q _2162_/X _2164_/X _2181_/X _2184_/X VGND VGND VPWR VPWR _2185_/X
+ sky130_fd_sc_hd__a2111o_1
XFILLER_43_19 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1969_ _2448_/A _2114_/D _2448_/D VGND VGND VPWR VPWR _1970_/A sky130_fd_sc_hd__or3_1
XFILLER_0_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_182 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2941_ _3055_/A _3175_/Q VGND VGND VPWR VPWR _2941_/X sky130_fd_sc_hd__or2_1
XFILLER_30_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2872_ _3353_/Q _1919_/X _3331_/D VGND VGND VPWR VPWR _3353_/D sky130_fd_sc_hd__mux2_1
X_1823_ _1778_/Y _1822_/X _1821_/B VGND VGND VPWR VPWR _1823_/Y sky130_fd_sc_hd__o21bai_1
X_1754_ _1740_/B _1752_/Y _1753_/Y VGND VGND VPWR VPWR _2018_/B sky130_fd_sc_hd__o21ai_1
X_1685_ _2459_/A _3202_/Q _3201_/Q _2550_/D VGND VGND VPWR VPWR _2626_/D sky130_fd_sc_hd__or4_1
X_3355_ _3356_/CLK _3355_/D VGND VGND VPWR VPWR _3355_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2306_ _3189_/Q _2162_/X _2164_/X input6/X _2305_/X VGND VGND VPWR VPWR _2306_/X
+ sky130_fd_sc_hd__a221o_1
X_3286_ _3287_/CLK _3286_/D VGND VGND VPWR VPWR _3286_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2237_ _2389_/A _3182_/Q _2441_/A VGND VGND VPWR VPWR _2237_/X sky130_fd_sc_hd__a21bo_1
XFILLER_57_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2168_ _2318_/A _3261_/Q _1644_/X _2137_/X _3231_/Q VGND VGND VPWR VPWR _2168_/X
+ sky130_fd_sc_hd__a32o_1
XFILLER_38_385 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2099_ _2644_/B _2098_/X _2630_/B _2733_/A _1872_/B VGND VGND VPWR VPWR _2101_/B
+ sky130_fd_sc_hd__a2111o_1
XFILLER_53_355 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_127 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_51 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3140_ _3345_/CLK _3140_/D VGND VGND VPWR VPWR _3140_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_67_458 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3071_ _3397_/Q _2906_/X _3070_/X VGND VGND VPWR VPWR _3397_/D sky130_fd_sc_hd__a21o_1
X_2022_ input6/X _2008_/Y _2021_/Y VGND VGND VPWR VPWR _2026_/C sky130_fd_sc_hd__o21ai_1
XFILLER_47_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2924_ _3169_/Q _2832_/A _2923_/X _2816_/X VGND VGND VPWR VPWR _2924_/X sky130_fd_sc_hd__o211a_1
X_2855_ _3336_/Q _1885_/X _3331_/D VGND VGND VPWR VPWR _3336_/D sky130_fd_sc_hd__mux2_1
X_1806_ _3246_/Q _3247_/Q _2021_/C _1818_/B VGND VGND VPWR VPWR _2012_/C sky130_fd_sc_hd__nand4_2
X_2786_ _3313_/Q _2747_/X _2785_/X VGND VGND VPWR VPWR _3313_/D sky130_fd_sc_hd__a21o_1
X_1737_ _1720_/X _1721_/Y _1730_/Y _1736_/Y VGND VGND VPWR VPWR _1737_/X sky130_fd_sc_hd__o211a_1
X_1668_ _2726_/A _2102_/D _2448_/D _1668_/D VGND VGND VPWR VPWR _1668_/X sky130_fd_sc_hd__or4_1
X_3407_ _3407_/CLK _3407_/D VGND VGND VPWR VPWR _3407_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1599_ _2520_/C _2448_/B _1599_/C _2434_/B VGND VGND VPWR VPWR _1599_/X sky130_fd_sc_hd__or4b_1
X_3338_ _3338_/CLK _3338_/D VGND VGND VPWR VPWR _3338_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3269_ _3278_/CLK _3269_/D VGND VGND VPWR VPWR _3269_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_26_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_248 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_31_i_clk clkbuf_leaf_1_i_clk/A VGND VGND VPWR VPWR _3404_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_1_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_344 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2640_ _2640_/A _2640_/B VGND VGND VPWR VPWR _2643_/A sky130_fd_sc_hd__nand2_1
XFILLER_72_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2571_ input12/X _3244_/Q _2574_/S VGND VGND VPWR VPWR _3244_/D sky130_fd_sc_hd__mux2_1
XFILLER_67_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3123_ _3123_/A _3123_/B VGND VGND VPWR VPWR _3125_/B sky130_fd_sc_hd__nor2_1
XFILLER_67_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3054_ _3394_/Q _3391_/Q _3084_/S VGND VGND VPWR VPWR _3054_/X sky130_fd_sc_hd__mux2_1
X_2005_ _2456_/B _1992_/X _2003_/Y _2626_/C VGND VGND VPWR VPWR _2005_/X sky130_fd_sc_hd__o31a_1
XFILLER_23_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2907_ _2907_/A VGND VGND VPWR VPWR _2907_/X sky130_fd_sc_hd__buf_8
XFILLER_31_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2838_ _2838_/A _2838_/B _2896_/C VGND VGND VPWR VPWR _2895_/B sky130_fd_sc_hd__and3_1
X_2769_ _3334_/Q _2768_/X _2740_/C _3301_/Q _2747_/X VGND VGND VPWR VPWR _3301_/D
+ sky130_fd_sc_hd__a32o_1
XFILLER_76_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2623_ _2851_/B _2633_/B _1854_/Y _1873_/B VGND VGND VPWR VPWR _2623_/X sky130_fd_sc_hd__o211a_1
Xoutput103 _3132_/Q VGND VGND VPWR VPWR o_wb_stall sky130_fd_sc_hd__clkbuf_1
X_2554_ _2554_/A VGND VGND VPWR VPWR _2574_/S sky130_fd_sc_hd__buf_8
X_2485_ _3246_/Q _3209_/Q VGND VGND VPWR VPWR _2485_/X sky130_fd_sc_hd__or2_1
X_3106_ _3202_/Q _3201_/Q _3100_/A _3101_/S VGND VGND VPWR VPWR _3106_/X sky130_fd_sc_hd__a31o_1
XFILLER_55_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3037_ _3055_/A _3191_/Q VGND VGND VPWR VPWR _3037_/X sky130_fd_sc_hd__or2_1
XFILLER_36_450 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput27 i_wb_data[0] VGND VGND VPWR VPWR input27/X sky130_fd_sc_hd__clkbuf_1
Xinput16 i_wb_addr[1] VGND VGND VPWR VPWR _2604_/A sky130_fd_sc_hd__buf_4
Xinput38 i_wb_data[1] VGND VGND VPWR VPWR input38/X sky130_fd_sc_hd__clkbuf_1
Xinput49 i_wb_data[2] VGND VGND VPWR VPWR input49/X sky130_fd_sc_hd__clkbuf_1
XFILLER_42_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2270_ _2594_/B _3257_/Q _2492_/C _2576_/B _3213_/Q VGND VGND VPWR VPWR _2270_/X
+ sky130_fd_sc_hd__a32o_1
XFILLER_37_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1985_ _2318_/A _2411_/B VGND VGND VPWR VPWR _2616_/C sky130_fd_sc_hd__nor2_4
X_2606_ _3203_/Q _2606_/B _2097_/B VGND VGND VPWR VPWR _2606_/X sky130_fd_sc_hd__or3b_1
X_2537_ _2318_/A _2411_/B _2102_/D _2543_/D _3225_/Q VGND VGND VPWR VPWR _2539_/B
+ sky130_fd_sc_hd__o41a_1
X_2468_ _2436_/C _2520_/C _2520_/A _3284_/Q VGND VGND VPWR VPWR _2468_/X sky130_fd_sc_hd__a31o_1
XFILLER_57_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2399_ _2492_/C _2371_/X _3285_/Q _2552_/A VGND VGND VPWR VPWR _2399_/X sky130_fd_sc_hd__a2bb2o_1
XFILLER_68_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_84 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1770_ _2021_/C _2020_/B _1796_/B _3246_/Q VGND VGND VPWR VPWR _2027_/B sky130_fd_sc_hd__a31o_1
XFILLER_8_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3371_ _3407_/CLK _3371_/D VGND VGND VPWR VPWR _3371_/Q sky130_fd_sc_hd__dfxtp_1
X_2322_ input7/X _1872_/B _2164_/X _2321_/X _2247_/D VGND VGND VPWR VPWR _2322_/X
+ sky130_fd_sc_hd__a311o_1
XFILLER_33_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2253_ _2389_/A _3184_/Q _2441_/A VGND VGND VPWR VPWR _2253_/X sky130_fd_sc_hd__a21bo_1
X_2184_ _2436_/C _1854_/Y _2182_/X _2183_/X VGND VGND VPWR VPWR _2184_/X sky130_fd_sc_hd__a22o_1
XFILLER_80_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1968_ _1968_/A VGND VGND VPWR VPWR _2801_/C sky130_fd_sc_hd__buf_6
X_1899_ _3141_/Q _3138_/Q _2884_/S VGND VGND VPWR VPWR _1899_/X sky130_fd_sc_hd__mux2_1
XFILLER_0_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_72 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2940_ _3375_/Q _3372_/Q _3093_/A VGND VGND VPWR VPWR _2940_/X sky130_fd_sc_hd__mux2_1
XFILLER_22_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2871_ _3352_/Q _1917_/X _3331_/D VGND VGND VPWR VPWR _3352_/D sky130_fd_sc_hd__mux2_1
X_1822_ _1778_/A _1815_/B _1815_/C _1778_/B VGND VGND VPWR VPWR _1822_/X sky130_fd_sc_hd__o31a_1
X_1753_ _1630_/Y _1740_/B _2604_/A VGND VGND VPWR VPWR _1753_/Y sky130_fd_sc_hd__o21bai_1
X_1684_ _2726_/A _2043_/B _2740_/A _2726_/C VGND VGND VPWR VPWR _2550_/D sky130_fd_sc_hd__or4_2
XTAP_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3354_ _3356_/CLK _3354_/D VGND VGND VPWR VPWR _3354_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2305_ _3238_/Q _2577_/D _2120_/B _2304_/X VGND VGND VPWR VPWR _2305_/X sky130_fd_sc_hd__o31a_1
X_3285_ _3287_/CLK _3285_/D VGND VGND VPWR VPWR _3285_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2236_ _3182_/Q _2162_/X _2164_/X _1720_/B _2235_/X VGND VGND VPWR VPWR _2236_/X
+ sky130_fd_sc_hd__a221o_1
XTAP_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_150 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2167_ _3231_/Q _2337_/C _2135_/X _2001_/X VGND VGND VPWR VPWR _2167_/X sky130_fd_sc_hd__a31o_1
XFILLER_38_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2098_ _2604_/A input5/X _2098_/C VGND VGND VPWR VPWR _2098_/X sky130_fd_sc_hd__or3_1
XFILLER_80_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_235 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_430 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3070_ _3197_/Q _2907_/X _2909_/X _3069_/X VGND VGND VPWR VPWR _3070_/X sky130_fd_sc_hd__o211a_1
X_2021_ _3246_/Q _3247_/Q _2021_/C _2021_/D VGND VGND VPWR VPWR _2021_/Y sky130_fd_sc_hd__nand4_1
XFILLER_47_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2923_ _3055_/A _3172_/Q VGND VGND VPWR VPWR _2923_/X sky130_fd_sc_hd__or2_1
X_2854_ _3335_/Q _1883_/X _3331_/D VGND VGND VPWR VPWR _3335_/D sky130_fd_sc_hd__mux2_1
X_2785_ _3346_/Q _2888_/S _2801_/C VGND VGND VPWR VPWR _2785_/X sky130_fd_sc_hd__and3_1
X_1805_ _3246_/Q _2021_/C _2020_/B _1796_/B _3247_/Q VGND VGND VPWR VPWR _2012_/B
+ sky130_fd_sc_hd__a41o_1
X_1736_ _1731_/X _1732_/Y _1735_/X VGND VGND VPWR VPWR _1736_/Y sky130_fd_sc_hd__o21ai_1
X_1667_ _3200_/Q _2459_/A VGND VGND VPWR VPWR _1668_/D sky130_fd_sc_hd__nor2_1
X_3406_ _3407_/CLK _3406_/D VGND VGND VPWR VPWR _3406_/Q sky130_fd_sc_hd__dfxtp_1
X_1598_ _3253_/Q VGND VGND VPWR VPWR _2434_/B sky130_fd_sc_hd__buf_8
XTAP_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3337_ _3338_/CLK _3337_/D VGND VGND VPWR VPWR _3337_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3268_ _3409_/CLK _3268_/D VGND VGND VPWR VPWR _3268_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2219_ _2520_/C _2368_/B _1644_/X _2218_/X VGND VGND VPWR VPWR _2219_/X sky130_fd_sc_hd__a31o_1
X_3199_ _3289_/CLK _3199_/D VGND VGND VPWR VPWR _3199_/Q sky130_fd_sc_hd__dfxtp_2
XFILLER_73_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_183 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_142 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_323 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2570_ _1804_/B _3243_/Q _2574_/S VGND VGND VPWR VPWR _3243_/D sky130_fd_sc_hd__mux2_1
XFILLER_4_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3122_ _3122_/A _3122_/B _3122_/C _3122_/D VGND VGND VPWR VPWR _3125_/A sky130_fd_sc_hd__or4_1
XFILLER_82_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3053_ _3394_/Q _2906_/X _3052_/X VGND VGND VPWR VPWR _3394_/D sky130_fd_sc_hd__a21o_1
XFILLER_48_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2004_ _2448_/B _2004_/B _2335_/A _2851_/B VGND VGND VPWR VPWR _2626_/C sky130_fd_sc_hd__or4b_1
XFILLER_23_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2906_ _2906_/A VGND VGND VPWR VPWR _2906_/X sky130_fd_sc_hd__buf_8
XFILLER_50_178 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2837_ _2837_/A _3367_/Q _2889_/B _2896_/C VGND VGND VPWR VPWR _2907_/A sky130_fd_sc_hd__or4b_4
X_2768_ _2585_/A _2368_/B _1656_/X _2888_/S VGND VGND VPWR VPWR _2768_/X sky130_fd_sc_hd__o31a_2
X_2699_ _3261_/Q input54/X _2717_/S VGND VGND VPWR VPWR _3261_/D sky130_fd_sc_hd__mux2_1
X_1719_ _2585_/A _2368_/B _3230_/Q _3231_/Q VGND VGND VPWR VPWR _1720_/A sky130_fd_sc_hd__a31o_1
XTAP_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2622_ _2739_/A _2086_/B _1608_/X _2621_/Y VGND VGND VPWR VPWR _2622_/X sky130_fd_sc_hd__a31o_1
XFILLER_63_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2553_ _2581_/B _2581_/C _2553_/C VGND VGND VPWR VPWR _2554_/A sky130_fd_sc_hd__or3_2
X_2484_ _3247_/Q _3210_/Q VGND VGND VPWR VPWR _2484_/X sky130_fd_sc_hd__or2_1
X_3105_ _3201_/Q _3100_/A _3104_/X VGND VGND VPWR VPWR _3105_/Y sky130_fd_sc_hd__a21oi_1
X_3036_ _3391_/Q _3388_/Q _3084_/S VGND VGND VPWR VPWR _3036_/X sky130_fd_sc_hd__mux2_1
XFILLER_55_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_30_i_clk clkbuf_leaf_1_i_clk/A VGND VGND VPWR VPWR _3405_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_63_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_454 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_226 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput17 i_wb_addr[2] VGND VGND VPWR VPWR input17/X sky130_fd_sc_hd__clkbuf_2
Xinput28 i_wb_data[10] VGND VGND VPWR VPWR input28/X sky130_fd_sc_hd__clkbuf_1
Xinput39 i_wb_data[20] VGND VGND VPWR VPWR input39/X sky130_fd_sc_hd__clkbuf_1
XFILLER_37_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_229 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1984_ _2543_/D _1983_/X _1977_/A VGND VGND VPWR VPWR _2626_/B sky130_fd_sc_hd__o21ai_4
XFILLER_60_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2605_ _2739_/C _2644_/B VGND VGND VPWR VPWR _2606_/B sky130_fd_sc_hd__and2_1
X_2536_ _2533_/X _3224_/Q _2692_/A _2535_/Y VGND VGND VPWR VPWR _3224_/D sky130_fd_sc_hd__a211o_1
X_2467_ _2090_/X _2630_/B _1608_/X _2466_/X VGND VGND VPWR VPWR _2467_/Y sky130_fd_sc_hd__a211oi_1
X_2398_ _1679_/B _2188_/A _2044_/X VGND VGND VPWR VPWR _2398_/Y sky130_fd_sc_hd__a21oi_1
XFILLER_28_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3019_ _3055_/A _3188_/Q VGND VGND VPWR VPWR _3019_/X sky130_fd_sc_hd__or2_1
XFILLER_24_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_240 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3370_ _3407_/CLK _3370_/D VGND VGND VPWR VPWR _3370_/Q sky130_fd_sc_hd__dfxtp_1
X_2321_ _2389_/C _1808_/B _2320_/X _1608_/X VGND VGND VPWR VPWR _2321_/X sky130_fd_sc_hd__o211a_1
X_2252_ _3184_/Q _2162_/X _2164_/X _1749_/A _2251_/X VGND VGND VPWR VPWR _2252_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_69_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2183_ _2318_/A _3263_/Q _1644_/X _2137_/X _3233_/Q VGND VGND VPWR VPWR _2183_/X
+ sky130_fd_sc_hd__a32o_1
XFILLER_65_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1967_ _2740_/A _1661_/A _2384_/C _1966_/X VGND VGND VPWR VPWR _1968_/A sky130_fd_sc_hd__a31o_1
X_1898_ _3141_/Q _1897_/X _1932_/S VGND VGND VPWR VPWR _3141_/D sky130_fd_sc_hd__mux2_1
X_2519_ _3218_/Q _2543_/C _2518_/X VGND VGND VPWR VPWR _2519_/X sky130_fd_sc_hd__or3b_1
XFILLER_68_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_240 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2870_ _3351_/Q _1915_/X _3331_/D VGND VGND VPWR VPWR _3351_/D sky130_fd_sc_hd__mux2_1
XFILLER_30_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1821_ _1821_/A _1821_/B VGND VGND VPWR VPWR _1821_/Y sky130_fd_sc_hd__nand2_1
X_1752_ _2585_/A _2368_/B _2604_/A VGND VGND VPWR VPWR _1752_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_7_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1683_ _2851_/B _2633_/B VGND VGND VPWR VPWR _1683_/X sky130_fd_sc_hd__and2b_1
XTAP_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3353_ _3353_/CLK _3353_/D VGND VGND VPWR VPWR _3353_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2304_ _2520_/C _1644_/X _2257_/X _3246_/Q _2303_/X VGND VGND VPWR VPWR _2304_/X
+ sky130_fd_sc_hd__a221o_1
X_3284_ _3287_/CLK _3284_/D VGND VGND VPWR VPWR _3284_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_57_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2235_ _2520_/C _3231_/Q _1644_/X _2234_/X VGND VGND VPWR VPWR _2235_/X sky130_fd_sc_hd__a31o_1
XTAP_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2166_ _2389_/C _1720_/B _2165_/X _1608_/X VGND VGND VPWR VPWR _2166_/X sky130_fd_sc_hd__o211a_1
XFILLER_38_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2097_ _2097_/A _2097_/B VGND VGND VPWR VPWR _2098_/C sky130_fd_sc_hd__and2_1
XFILLER_21_210 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2999_ _3385_/Q _2906_/X _2998_/X VGND VGND VPWR VPWR _3385_/D sky130_fd_sc_hd__a21o_1
XFILLER_21_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_173 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_442 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2020_ _3243_/Q _2020_/B _2020_/C _2020_/D VGND VGND VPWR VPWR _2021_/D sky130_fd_sc_hd__and4_1
XFILLER_75_471 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_357 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2922_ _2922_/A VGND VGND VPWR VPWR _3100_/A sky130_fd_sc_hd__buf_8
XFILLER_50_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2853_ _3334_/Q _1878_/X _3331_/D VGND VGND VPWR VPWR _3334_/D sky130_fd_sc_hd__mux2_1
X_2784_ _3312_/Q _2747_/X _2783_/X VGND VGND VPWR VPWR _3312_/D sky130_fd_sc_hd__a21o_1
X_1804_ _1802_/Y _1804_/B _1804_/C VGND VGND VPWR VPWR _1804_/Y sky130_fd_sc_hd__nand3b_1
X_1735_ _1733_/Y _1734_/X input19/X VGND VGND VPWR VPWR _1735_/X sky130_fd_sc_hd__a21o_1
X_1666_ _2384_/C _2740_/A VGND VGND VPWR VPWR _2102_/D sky130_fd_sc_hd__nand2_8
X_3405_ _3405_/CLK _3405_/D VGND VGND VPWR VPWR _3405_/Q sky130_fd_sc_hd__dfxtp_1
X_1597_ _2594_/B _2424_/A VGND VGND VPWR VPWR _1599_/C sky130_fd_sc_hd__and2_1
XTAP_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3336_ _3338_/CLK _3336_/D VGND VGND VPWR VPWR _3336_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3267_ _3409_/CLK _3267_/D VGND VGND VPWR VPWR _3267_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2218_ _3237_/Q _2207_/X _2217_/X _2209_/X VGND VGND VPWR VPWR _2218_/X sky130_fd_sc_hd__o211a_1
X_3198_ _3204_/CLK _3198_/D VGND VGND VPWR VPWR _3198_/Q sky130_fd_sc_hd__dfxtp_2
X_2149_ _2520_/B _1854_/Y _2147_/X _2148_/X VGND VGND VPWR VPWR _2149_/X sky130_fd_sc_hd__a22o_1
XFILLER_38_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_154 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3121_ _3407_/Q _3114_/X _3120_/X _2907_/X VGND VGND VPWR VPWR _3407_/D sky130_fd_sc_hd__a22o_1
X_3052_ _3194_/Q _2907_/X _2909_/X _3051_/X VGND VGND VPWR VPWR _3052_/X sky130_fd_sc_hd__o211a_1
XFILLER_67_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2003_ _2668_/B _1999_/Y _2002_/Y VGND VGND VPWR VPWR _2003_/Y sky130_fd_sc_hd__a21oi_1
XFILLER_35_143 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2905_ _2889_/B _1573_/B _2896_/C _2896_/X _2818_/Y VGND VGND VPWR VPWR _2906_/A
+ sky130_fd_sc_hd__a311o_4
X_2836_ _3327_/Q _2829_/A _2821_/X _2835_/X VGND VGND VPWR VPWR _3327_/D sky130_fd_sc_hd__o22a_1
X_2767_ _3300_/Q _2888_/S _2766_/X VGND VGND VPWR VPWR _3300_/D sky130_fd_sc_hd__o21a_1
X_2698_ _3260_/Q input53/X _2717_/S VGND VGND VPWR VPWR _3260_/D sky130_fd_sc_hd__mux2_1
XFILLER_2_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1718_ _1718_/A _1718_/B VGND VGND VPWR VPWR _2013_/B sky130_fd_sc_hd__nand2_1
X_1649_ _1679_/B VGND VGND VPWR VPWR _2188_/B sky130_fd_sc_hd__inv_8
XFILLER_76_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3319_ _3363_/CLK _3319_/D VGND VGND VPWR VPWR _3319_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_22 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_88 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_168 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2621_ _2318_/A _2618_/X _2620_/X VGND VGND VPWR VPWR _2621_/Y sky130_fd_sc_hd__o21ai_1
X_2552_ _2552_/A _2552_/B _2552_/C _2551_/X VGND VGND VPWR VPWR _2553_/C sky130_fd_sc_hd__or4b_1
XFILLER_56_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2483_ _3247_/Q _3210_/Q VGND VGND VPWR VPWR _2483_/Y sky130_fd_sc_hd__nand2_1
X_3104_ _3102_/X _3103_/Y _3202_/Q _2826_/X VGND VGND VPWR VPWR _3104_/X sky130_fd_sc_hd__o2bb2a_1
XFILLER_28_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3035_ _3391_/Q _2906_/X _3034_/X VGND VGND VPWR VPWR _3391_/D sky130_fd_sc_hd__a21o_1
XFILLER_55_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_411 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2819_ _2889_/B _2896_/C _2819_/C VGND VGND VPWR VPWR _2820_/A sky130_fd_sc_hd__and3b_1
XFILLER_11_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput18 i_wb_addr[3] VGND VGND VPWR VPWR _1720_/B sky130_fd_sc_hd__clkbuf_2
XFILLER_10_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput29 i_wb_data[11] VGND VGND VPWR VPWR input29/X sky130_fd_sc_hd__clkbuf_1
XFILLER_28_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_260 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1983_ _3227_/Q _3226_/Q _3225_/Q VGND VGND VPWR VPWR _1983_/X sky130_fd_sc_hd__or3_2
X_2604_ _2604_/A input5/X VGND VGND VPWR VPWR _2644_/C sky130_fd_sc_hd__or2b_1
X_2535_ _2543_/C _2543_/D _1983_/X VGND VGND VPWR VPWR _2535_/Y sky130_fd_sc_hd__nor3b_1
X_2466_ _1679_/B _2188_/A _2463_/X _2398_/Y _2465_/X VGND VGND VPWR VPWR _2466_/X
+ sky130_fd_sc_hd__a311o_1
XFILLER_28_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2397_ _2188_/B _2161_/B _3198_/Q _1650_/Y VGND VGND VPWR VPWR _2397_/X sky130_fd_sc_hd__a31o_1
XFILLER_68_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3018_ _3388_/Q _3385_/Q _3093_/A VGND VGND VPWR VPWR _3018_/X sky130_fd_sc_hd__mux2_1
XFILLER_24_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_20 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2320_ _2161_/B _3190_/Q _2441_/A VGND VGND VPWR VPWR _2320_/X sky130_fd_sc_hd__a21bo_1
X_2251_ _2520_/C _3233_/Q _1644_/X _2250_/X VGND VGND VPWR VPWR _2251_/X sky130_fd_sc_hd__a31o_1
X_2182_ _3233_/Q _2337_/C _2135_/X _2001_/X VGND VGND VPWR VPWR _2182_/X sky130_fd_sc_hd__a31o_1
XFILLER_65_344 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1966_ _3254_/Q _3253_/Q _2520_/B _2448_/A VGND VGND VPWR VPWR _1966_/X sky130_fd_sc_hd__and4_1
X_1897_ _3140_/Q _3137_/Q _2884_/S VGND VGND VPWR VPWR _1897_/X sky130_fd_sc_hd__mux2_1
X_2518_ _3227_/Q _3226_/Q _3225_/Q _2543_/D VGND VGND VPWR VPWR _2518_/X sky130_fd_sc_hd__or4_1
XFILLER_75_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2449_ _1679_/B _2188_/A _3248_/Q _2436_/C _2492_/A VGND VGND VPWR VPWR _2449_/X
+ sky130_fd_sc_hd__o311a_1
XFILLER_68_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_182 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_458 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_52 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1820_ _1778_/A _1815_/B _1815_/C _1778_/B VGND VGND VPWR VPWR _1821_/A sky130_fd_sc_hd__o31ai_1
X_1751_ _1751_/A _1751_/B VGND VGND VPWR VPWR _1762_/B sky130_fd_sc_hd__nand2_1
XFILLER_7_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1682_ _1679_/Y _2613_/A _2494_/B _1638_/X _2494_/A VGND VGND VPWR VPWR _1682_/X
+ sky130_fd_sc_hd__a41o_1
X_3352_ _3353_/CLK _3352_/D VGND VGND VPWR VPWR _3352_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2303_ _3276_/Q _1844_/B _2301_/X _2302_/X VGND VGND VPWR VPWR _2303_/X sky130_fd_sc_hd__o22a_1
XTAP_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3283_ _3287_/CLK _3283_/D VGND VGND VPWR VPWR _3283_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2234_ _3239_/Q _2207_/X _2233_/X _2209_/X VGND VGND VPWR VPWR _2234_/X sky130_fd_sc_hd__o211a_1
XTAP_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2165_ _2161_/B _3174_/Q _2441_/A VGND VGND VPWR VPWR _2165_/X sky130_fd_sc_hd__a21bo_1
XFILLER_38_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2096_ _3203_/Q _2090_/X _2335_/C _2095_/X VGND VGND VPWR VPWR _2096_/X sky130_fd_sc_hd__a31o_1
XFILLER_53_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2998_ _3185_/Q _2907_/X _2909_/X _2997_/X VGND VGND VPWR VPWR _2998_/X sky130_fd_sc_hd__o211a_1
XFILLER_21_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1949_ _2434_/B _2384_/B _2436_/C VGND VGND VPWR VPWR _1955_/C sky130_fd_sc_hd__and3_2
XFILLER_0_126 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_100 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_155 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_454 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_369 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2921_ _3372_/Q _3401_/Q _3093_/A VGND VGND VPWR VPWR _2921_/X sky130_fd_sc_hd__mux2_1
XFILLER_50_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2852_ _2896_/C _2895_/A _2816_/X _2903_/D VGND VGND VPWR VPWR _3332_/D sky130_fd_sc_hd__a2bb2o_1
X_2783_ _3345_/Q _2888_/S _2801_/C VGND VGND VPWR VPWR _2783_/X sky130_fd_sc_hd__and3_1
X_1803_ _1818_/B _1802_/Y _1804_/B VGND VGND VPWR VPWR _1803_/Y sky130_fd_sc_hd__o21bai_1
X_1734_ _2585_/A _2368_/B _3230_/Q _3231_/Q _3232_/Q VGND VGND VPWR VPWR _1734_/X
+ sky130_fd_sc_hd__a41o_1
XFILLER_7_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3404_ _3404_/CLK _3404_/D VGND VGND VPWR VPWR _3404_/Q sky130_fd_sc_hd__dfxtp_1
X_1665_ _1665_/A _2726_/D _2520_/C VGND VGND VPWR VPWR _1665_/X sky130_fd_sc_hd__and3_1
X_1596_ _3254_/Q VGND VGND VPWR VPWR _2424_/A sky130_fd_sc_hd__buf_8
XTAP_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3335_ _3338_/CLK _3335_/D VGND VGND VPWR VPWR _3335_/Q sky130_fd_sc_hd__dfxtp_1
X_3266_ _3266_/CLK _3266_/D VGND VGND VPWR VPWR _3266_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2217_ _3267_/Q _2552_/A _2576_/B _3259_/Q _2137_/X VGND VGND VPWR VPWR _2217_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_38_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3197_ _3200_/CLK _3197_/D VGND VGND VPWR VPWR _3197_/Q sky130_fd_sc_hd__dfxtp_2
XFILLER_38_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2148_ _2318_/A _3259_/Q _1644_/X _2137_/X _2368_/B VGND VGND VPWR VPWR _2148_/X
+ sky130_fd_sc_hd__a32o_1
XFILLER_66_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2079_ _3055_/A _2071_/Y _2076_/X _2078_/X VGND VGND VPWR VPWR _3167_/D sky130_fd_sc_hd__o211a_1
XFILLER_53_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_86 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3120_ _3118_/X _3114_/X _3407_/Q _3119_/X VGND VGND VPWR VPWR _3120_/X sky130_fd_sc_hd__a2bb2o_1
X_3051_ _3048_/X _2826_/X _3100_/A _3050_/X VGND VGND VPWR VPWR _3051_/X sky130_fd_sc_hd__a211o_1
XFILLER_48_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2002_ _1683_/X _1653_/A _2001_/X VGND VGND VPWR VPWR _2002_/Y sky130_fd_sc_hd__a21oi_1
XFILLER_35_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2904_ _2889_/B _2897_/X _2903_/X VGND VGND VPWR VPWR _3369_/D sky130_fd_sc_hd__a21o_1
XFILLER_50_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2835_ _2831_/Y _3400_/Q _2816_/X _3200_/Q _2832_/X VGND VGND VPWR VPWR _2835_/X
+ sky130_fd_sc_hd__o32a_1
X_2766_ _3364_/Q _2801_/C _2745_/X _3211_/Q _2747_/A VGND VGND VPWR VPWR _2766_/X
+ sky130_fd_sc_hd__a221o_1
X_2697_ _3259_/Q input52/X _2717_/S VGND VGND VPWR VPWR _3259_/D sky130_fd_sc_hd__mux2_1
X_1717_ _1716_/A _1716_/B _2335_/B VGND VGND VPWR VPWR _1718_/B sky130_fd_sc_hd__a21o_1
X_1648_ _1998_/C _2575_/S _1644_/X _2424_/D _1647_/X VGND VGND VPWR VPWR _1648_/Y
+ sky130_fd_sc_hd__a221oi_1
X_3318_ _3363_/CLK _3318_/D VGND VGND VPWR VPWR _3318_/Q sky130_fd_sc_hd__dfxtp_1
X_1579_ _2896_/C _3130_/Q _3250_/Q VGND VGND VPWR VPWR _1579_/X sky130_fd_sc_hd__mux2_1
XTAP_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3249_ _3289_/CLK _3249_/D VGND VGND VPWR VPWR _3249_/Q sky130_fd_sc_hd__dfxtp_1
XPHY_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_136 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_298 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2620_ _3200_/Q _3198_/Q _2619_/Y _2120_/B _2114_/D VGND VGND VPWR VPWR _2620_/X
+ sky130_fd_sc_hd__a311o_1
X_2551_ _1955_/A _2551_/B _2741_/C _2551_/D VGND VGND VPWR VPWR _2551_/X sky130_fd_sc_hd__and4b_1
X_2482_ _1766_/B _3208_/Q _2478_/X _2481_/X _2552_/C VGND VGND VPWR VPWR _2482_/Y
+ sky130_fd_sc_hd__o2111ai_1
X_3103_ _3403_/Q _3097_/B _3404_/Q VGND VGND VPWR VPWR _3103_/Y sky130_fd_sc_hd__o21ai_1
X_3034_ _3191_/Q _2907_/X _2909_/X _3033_/X VGND VGND VPWR VPWR _3034_/X sky130_fd_sc_hd__o211a_1
XFILLER_36_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2818_ _2896_/C _2895_/A VGND VGND VPWR VPWR _2818_/Y sky130_fd_sc_hd__nor2_2
X_2749_ _3291_/Q _2888_/S _2748_/X VGND VGND VPWR VPWR _3291_/D sky130_fd_sc_hd__o21a_1
XFILLER_11_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_294 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput19 i_wb_addr[4] VGND VGND VPWR VPWR input19/X sky130_fd_sc_hd__clkbuf_2
XFILLER_77_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1982_ _3220_/Q _3219_/Q _3218_/Q _1982_/D VGND VGND VPWR VPWR _2543_/D sky130_fd_sc_hd__or4_4
XFILLER_20_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2603_ _2588_/X _2601_/Y _2384_/C _2602_/X VGND VGND VPWR VPWR _2640_/A sky130_fd_sc_hd__o2bb2ai_1
X_2534_ _2692_/A _2534_/B _2533_/X VGND VGND VPWR VPWR _3223_/D sky130_fd_sc_hd__or3b_1
X_2465_ _2335_/A _3122_/A _2091_/C _2739_/C _2464_/X VGND VGND VPWR VPWR _2465_/X
+ sky130_fd_sc_hd__a221o_1
X_2396_ _2335_/A _2740_/C _2395_/X _2129_/X VGND VGND VPWR VPWR _2396_/X sky130_fd_sc_hd__o31a_1
XFILLER_68_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3017_ _3388_/Q _2906_/X _3016_/X VGND VGND VPWR VPWR _3388_/D sky130_fd_sc_hd__a21o_1
XFILLER_24_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_297 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2250_ _3241_/Q _2207_/X _2249_/X _2209_/X VGND VGND VPWR VPWR _2250_/X sky130_fd_sc_hd__o211a_1
X_2181_ _2389_/C _1749_/A _2180_/X _1608_/X VGND VGND VPWR VPWR _2181_/X sky130_fd_sc_hd__o211a_1
XFILLER_65_323 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1965_ _1956_/X _2613_/C _2547_/A VGND VGND VPWR VPWR _2070_/C sky130_fd_sc_hd__a21boi_1
X_1896_ _3140_/Q _1895_/X _1932_/S VGND VGND VPWR VPWR _3140_/D sky130_fd_sc_hd__mux2_1
X_2517_ _2626_/B _3218_/Q VGND VGND VPWR VPWR _2517_/Y sky130_fd_sc_hd__nand2_1
X_2448_ _2448_/A _2448_/B _2594_/B _2448_/D VGND VGND VPWR VPWR _2448_/X sky130_fd_sc_hd__or4_2
X_2379_ _2726_/A _3284_/Q _1644_/X _2339_/X VGND VGND VPWR VPWR _2379_/X sky130_fd_sc_hd__a31o_1
XFILLER_68_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1750_ _1815_/B _1695_/Y _1746_/Y _1749_/Y VGND VGND VPWR VPWR _1751_/B sky130_fd_sc_hd__o211ai_1
XFILLER_11_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1681_ _2616_/D _2448_/A _2520_/A VGND VGND VPWR VPWR _2494_/A sky130_fd_sc_hd__and3_4
X_3351_ _3353_/CLK _3351_/D VGND VGND VPWR VPWR _3351_/Q sky130_fd_sc_hd__dfxtp_1
X_2302_ _3216_/Q _2576_/B _2291_/X _3260_/Q _2552_/A VGND VGND VPWR VPWR _2302_/X
+ sky130_fd_sc_hd__a221o_1
XTAP_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3282_ _3338_/CLK _3282_/D VGND VGND VPWR VPWR _3282_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2233_ _3269_/Q _2552_/A _2576_/B _3261_/Q _2137_/X VGND VGND VPWR VPWR _2233_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_38_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2164_ _2164_/A VGND VGND VPWR VPWR _2164_/X sky130_fd_sc_hd__clkbuf_8
XFILLER_65_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2095_ _2097_/B _2086_/B _1611_/Y _2091_/X _2094_/X VGND VGND VPWR VPWR _2095_/X
+ sky130_fd_sc_hd__a41o_1
XFILLER_80_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2997_ _2994_/X _2826_/X _3100_/A _2996_/X VGND VGND VPWR VPWR _2997_/X sky130_fd_sc_hd__a211o_1
XFILLER_21_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1948_ _2726_/A _2520_/A _2616_/D _1947_/X VGND VGND VPWR VPWR _1960_/A sky130_fd_sc_hd__a31o_1
X_1879_ _2889_/B _2896_/C _2837_/A VGND VGND VPWR VPWR _1880_/A sky130_fd_sc_hd__and3b_2
XFILLER_0_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_156 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2920_ _3372_/Q _2906_/X _2919_/X VGND VGND VPWR VPWR _3372_/D sky130_fd_sc_hd__a21o_1
X_2851_ _2851_/A _2851_/B _2851_/C VGND VGND VPWR VPWR _2903_/D sky130_fd_sc_hd__or3_1
X_2782_ _3311_/Q _2747_/X _2781_/X VGND VGND VPWR VPWR _3311_/D sky130_fd_sc_hd__a21o_1
XFILLER_79_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1802_ _2020_/B _2020_/C _2020_/D _3243_/Q VGND VGND VPWR VPWR _1802_/Y sky130_fd_sc_hd__a31oi_2
X_1733_ _3232_/Q _1810_/B VGND VGND VPWR VPWR _1733_/Y sky130_fd_sc_hd__nand2_1
XFILLER_7_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3403_ _3404_/CLK _3403_/D VGND VGND VPWR VPWR _3403_/Q sky130_fd_sc_hd__dfxtp_1
X_1664_ _3202_/Q _3201_/Q _2459_/A VGND VGND VPWR VPWR _2726_/D sky130_fd_sc_hd__nor3_1
X_1595_ _1851_/C VGND VGND VPWR VPWR _2594_/B sky130_fd_sc_hd__buf_12
XTAP_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3334_ _3356_/CLK _3334_/D VGND VGND VPWR VPWR _3334_/Q sky130_fd_sc_hd__dfxtp_4
X_3265_ _3266_/CLK _3265_/D VGND VGND VPWR VPWR _3265_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2216_ _3179_/Q _2129_/X _2212_/X _2215_/X VGND VGND VPWR VPWR _3179_/D sky130_fd_sc_hd__o22a_1
XTAP_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3196_ _3204_/CLK _3196_/D VGND VGND VPWR VPWR _3196_/Q sky130_fd_sc_hd__dfxtp_2
X_2147_ _2368_/B _2337_/C _2146_/X _2001_/X VGND VGND VPWR VPWR _2147_/X sky130_fd_sc_hd__a31o_1
XFILLER_38_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2078_ _2078_/A VGND VGND VPWR VPWR _2078_/X sky130_fd_sc_hd__buf_4
XFILLER_81_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_178 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_98 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3050_ _2832_/A _3190_/Q _3049_/X _2816_/X VGND VGND VPWR VPWR _3050_/X sky130_fd_sc_hd__o211a_1
X_2001_ _2001_/A VGND VGND VPWR VPWR _2001_/X sky130_fd_sc_hd__buf_4
XFILLER_82_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2903_ _3108_/D _2907_/A _2903_/C _2903_/D VGND VGND VPWR VPWR _2903_/X sky130_fd_sc_hd__and4b_1
X_2834_ _3326_/Q _2829_/A _2821_/X _2833_/X VGND VGND VPWR VPWR _3326_/D sky130_fd_sc_hd__o22a_1
X_2765_ _3299_/Q _2888_/S _2764_/X VGND VGND VPWR VPWR _3299_/D sky130_fd_sc_hd__o21a_1
X_2696_ _3258_/Q input49/X _2717_/S VGND VGND VPWR VPWR _3258_/D sky130_fd_sc_hd__mux2_1
X_1716_ _1716_/A _1716_/B _2335_/B VGND VGND VPWR VPWR _1718_/A sky130_fd_sc_hd__nand3_1
X_1647_ _2424_/A _2434_/B _1873_/B _2448_/A VGND VGND VPWR VPWR _1647_/X sky130_fd_sc_hd__and4_4
X_3317_ _3363_/CLK _3317_/D VGND VGND VPWR VPWR _3317_/Q sky130_fd_sc_hd__dfxtp_1
X_1578_ _2851_/A _2896_/C _1567_/X _2806_/S _1577_/Y VGND VGND VPWR VPWR _3333_/D
+ sky130_fd_sc_hd__o32a_1
XTAP_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3248_ _3338_/CLK _3248_/D VGND VGND VPWR VPWR _3248_/Q sky130_fd_sc_hd__dfxtp_4
X_3179_ _3391_/CLK _3179_/D VGND VGND VPWR VPWR _3179_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_54_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_410 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2550_ _2550_/A _2550_/B _2741_/B _2550_/D VGND VGND VPWR VPWR _2551_/B sky130_fd_sc_hd__and4_1
X_2481_ _3244_/Q _2479_/Y _3206_/Q _2480_/Y VGND VGND VPWR VPWR _2481_/X sky130_fd_sc_hd__o22a_1
X_3102_ _3403_/Q _3404_/Q _3097_/B _2825_/B _2895_/A VGND VGND VPWR VPWR _3102_/X
+ sky130_fd_sc_hd__o32a_1
X_3033_ _3030_/X _2826_/X _3100_/A _3032_/X VGND VGND VPWR VPWR _3033_/X sky130_fd_sc_hd__a211o_1
XFILLER_51_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2817_ _2838_/A _2851_/C _2810_/X _2811_/X _2816_/X VGND VGND VPWR VPWR _2817_/X
+ sky130_fd_sc_hd__o32a_1
XFILLER_11_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2748_ _3348_/Q _2801_/C _2745_/X _3205_/Q _2747_/X VGND VGND VPWR VPWR _2748_/X
+ sky130_fd_sc_hd__a221o_1
X_2679_ _2616_/D _1661_/A _3122_/B _3122_/C VGND VGND VPWR VPWR _2680_/C sky130_fd_sc_hd__a211oi_1
XTAP_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_343 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1981_ _3224_/Q _3223_/Q _3222_/Q _3221_/Q VGND VGND VPWR VPWR _1982_/D sky130_fd_sc_hd__or4_1
XFILLER_13_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2602_ _2664_/B _2335_/A _2318_/A _2411_/B VGND VGND VPWR VPWR _2602_/X sky130_fd_sc_hd__a211o_1
X_2533_ _3223_/Q _3222_/Q _3221_/Q _2533_/D VGND VGND VPWR VPWR _2533_/X sky130_fd_sc_hd__or4_1
X_2464_ _2740_/C _2120_/C _2494_/B VGND VGND VPWR VPWR _2464_/X sky130_fd_sc_hd__mux2_1
X_2395_ _2392_/X _2733_/A _2393_/X _2394_/X VGND VGND VPWR VPWR _2395_/X sky130_fd_sc_hd__a31o_1
XFILLER_3_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3016_ _3188_/Q _2907_/X _2909_/X _3015_/X VGND VGND VPWR VPWR _3016_/X sky130_fd_sc_hd__o211a_1
XFILLER_36_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2180_ _2161_/B _3176_/Q _2441_/A VGND VGND VPWR VPWR _2180_/X sky130_fd_sc_hd__a21bo_1
XFILLER_77_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_287 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1964_ _2575_/S _1964_/B _1964_/C _1964_/D VGND VGND VPWR VPWR _2547_/A sky130_fd_sc_hd__and4b_1
X_1895_ _3139_/Q _3136_/Q _2884_/S VGND VGND VPWR VPWR _1895_/X sky130_fd_sc_hd__mux2_1
XFILLER_0_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2516_ _3217_/Q _2497_/Y _2515_/X _2078_/X VGND VGND VPWR VPWR _3217_/D sky130_fd_sc_hd__o211a_1
X_2447_ _2188_/B _3202_/Q _2161_/B _2120_/B VGND VGND VPWR VPWR _2447_/X sky130_fd_sc_hd__a31o_1
X_2378_ _2368_/B _2377_/Y _2146_/X _2044_/X VGND VGND VPWR VPWR _2378_/X sky130_fd_sc_hd__a211o_1
XFILLER_71_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1680_ _2384_/C _1851_/C VGND VGND VPWR VPWR _2616_/D sky130_fd_sc_hd__nor2_8
X_3350_ _3350_/CLK _3350_/D VGND VGND VPWR VPWR _3350_/Q sky130_fd_sc_hd__dfxtp_1
X_2301_ _3274_/Q _2616_/D _2313_/C VGND VGND VPWR VPWR _2301_/X sky130_fd_sc_hd__and3_2
XTAP_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3281_ _3287_/CLK _3281_/D VGND VGND VPWR VPWR _3281_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2232_ _3181_/Q _2129_/X _2228_/X _2231_/X VGND VGND VPWR VPWR _3181_/D sky130_fd_sc_hd__o22a_1
XTAP_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2163_ _2335_/A _3122_/A _2335_/C VGND VGND VPWR VPWR _2164_/A sky130_fd_sc_hd__and3_1
X_2094_ _2520_/B _1854_/Y _2120_/C _2093_/X VGND VGND VPWR VPWR _2094_/X sky130_fd_sc_hd__a31o_1
XFILLER_0_72 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2996_ _2832_/A _3181_/Q _2995_/X _2816_/X VGND VGND VPWR VPWR _2996_/X sky130_fd_sc_hd__o211a_1
X_1947_ _2424_/A _2114_/D _2434_/B _2726_/A VGND VGND VPWR VPWR _1947_/X sky130_fd_sc_hd__and4b_1
X_1878_ input2/X input1/X _2884_/S VGND VGND VPWR VPWR _1878_/X sky130_fd_sc_hd__mux2_1
XFILLER_0_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_471 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_132 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_371 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_168 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2850_ _2885_/S VGND VGND VPWR VPWR _3331_/D sky130_fd_sc_hd__clkbuf_16
X_1801_ _3240_/Q _3241_/Q _3242_/Q VGND VGND VPWR VPWR _2020_/C sky130_fd_sc_hd__and3_1
X_2781_ _3344_/Q _2888_/S _2801_/C VGND VGND VPWR VPWR _2781_/X sky130_fd_sc_hd__and3_1
XFILLER_11_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1732_ _3232_/Q _1810_/B input19/X VGND VGND VPWR VPWR _1732_/Y sky130_fd_sc_hd__o21ai_1
X_1663_ _3331_/Q VGND VGND VPWR VPWR _2459_/A sky130_fd_sc_hd__clkinv_4
X_3402_ _3407_/CLK _3402_/D VGND VGND VPWR VPWR _3402_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1594_ _2740_/A VGND VGND VPWR VPWR _1851_/C sky130_fd_sc_hd__inv_6
X_3333_ _3405_/CLK _3333_/D VGND VGND VPWR VPWR _3333_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3264_ _3266_/CLK _3264_/D VGND VGND VPWR VPWR _3264_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2215_ _2733_/A _2090_/X _2214_/X _2247_/D VGND VGND VPWR VPWR _2215_/X sky130_fd_sc_hd__a31o_1
XTAP_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3195_ _3204_/CLK _3195_/D VGND VGND VPWR VPWR _3195_/Q sky130_fd_sc_hd__dfxtp_2
X_2146_ _2188_/A _2188_/B VGND VGND VPWR VPWR _2146_/X sky130_fd_sc_hd__or2_1
XFILLER_38_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2077_ _2318_/A _2448_/B _2335_/A _2411_/B VGND VGND VPWR VPWR _2078_/A sky130_fd_sc_hd__or4_1
XFILLER_34_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2979_ _2976_/X _2826_/X _3100_/A _2978_/X VGND VGND VPWR VPWR _2979_/X sky130_fd_sc_hd__a211o_1
XFILLER_30_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_341 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2000_ _2448_/A _2424_/A _2434_/B _2577_/D VGND VGND VPWR VPWR _2001_/A sky130_fd_sc_hd__or4_1
XFILLER_35_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_371 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2902_ _2837_/A _2813_/C _2895_/A VGND VGND VPWR VPWR _3108_/D sky130_fd_sc_hd__a21o_1
XFILLER_50_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2833_ _2831_/Y _3399_/Q _2816_/X _3199_/Q _2832_/X VGND VGND VPWR VPWR _2833_/X
+ sky130_fd_sc_hd__o32a_1
XFILLER_31_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2764_ _3363_/Q _2801_/C _2745_/X _2851_/B _2747_/X VGND VGND VPWR VPWR _2764_/X
+ sky130_fd_sc_hd__a221o_1
X_1715_ _3242_/Q _2020_/B _1715_/C _2020_/D VGND VGND VPWR VPWR _1716_/B sky130_fd_sc_hd__nand4_1
X_2695_ _3257_/Q input38/X _2717_/S VGND VGND VPWR VPWR _3257_/D sky130_fd_sc_hd__mux2_1
X_1646_ _2043_/B _1851_/C VGND VGND VPWR VPWR _1873_/B sky130_fd_sc_hd__nor2_8
X_1577_ _3166_/Q _2838_/B _2838_/A VGND VGND VPWR VPWR _1577_/Y sky130_fd_sc_hd__o21ai_1
X_3316_ _3356_/CLK _3316_/D VGND VGND VPWR VPWR _3316_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3247_ _3365_/CLK _3247_/D VGND VGND VPWR VPWR _3247_/Q sky130_fd_sc_hd__dfxtp_4
X_3178_ _3391_/CLK _3178_/D VGND VGND VPWR VPWR _3178_/Q sky130_fd_sc_hd__dfxtp_1
X_2129_ _2129_/A VGND VGND VPWR VPWR _2129_/X sky130_fd_sc_hd__buf_12
XFILLER_81_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_422 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2480_ _3243_/Q VGND VGND VPWR VPWR _2480_/Y sky130_fd_sc_hd__inv_2
Xoutput90 _3297_/Q VGND VGND VPWR VPWR o_wb_data[27] sky130_fd_sc_hd__clkbuf_1
X_3101_ _3100_/X _3403_/Q _3101_/S VGND VGND VPWR VPWR _3403_/D sky130_fd_sc_hd__mux2_1
X_3032_ _2832_/A _3187_/Q _3031_/X _2816_/X VGND VGND VPWR VPWR _3032_/X sky130_fd_sc_hd__o211a_1
XFILLER_63_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2816_ _2816_/A VGND VGND VPWR VPWR _2816_/X sky130_fd_sc_hd__buf_8
XFILLER_11_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2747_ _2747_/A VGND VGND VPWR VPWR _2747_/X sky130_fd_sc_hd__buf_8
X_2678_ _2188_/B _2001_/X _2066_/X _1998_/C _2677_/X VGND VGND VPWR VPWR _2680_/B
+ sky130_fd_sc_hd__o221a_1
X_1629_ _3229_/Q VGND VGND VPWR VPWR _2368_/B sky130_fd_sc_hd__buf_8
XTAP_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_411 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1980_ _1943_/X _3164_/Q _1980_/S VGND VGND VPWR VPWR _3164_/D sky130_fd_sc_hd__mux2_1
XFILLER_60_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2601_ _2589_/X _2600_/Y _2039_/B VGND VGND VPWR VPWR _2601_/Y sky130_fd_sc_hd__o21bai_2
X_2532_ _3222_/Q _3221_/Q _2533_/D _3223_/Q VGND VGND VPWR VPWR _2534_/B sky130_fd_sc_hd__o31a_1
XFILLER_54_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2463_ _2494_/B _2613_/A _2463_/C VGND VGND VPWR VPWR _2463_/X sky130_fd_sc_hd__and3_1
X_2394_ _2604_/A input5/X _2616_/B VGND VGND VPWR VPWR _2394_/X sky130_fd_sc_hd__and3b_1
X_3015_ _3012_/X _2826_/X _3100_/A _3014_/X VGND VGND VPWR VPWR _3015_/X sky130_fd_sc_hd__a211o_1
XFILLER_24_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_82_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1963_ _2726_/A _2726_/C _2448_/B _2075_/B _1962_/X VGND VGND VPWR VPWR _1964_/D
+ sky130_fd_sc_hd__o311a_1
X_1894_ _3139_/Q _1893_/X _1932_/S VGND VGND VPWR VPWR _3139_/D sky130_fd_sc_hd__mux2_1
X_2515_ _3341_/Q _2110_/C _2514_/X _2499_/X VGND VGND VPWR VPWR _2515_/X sky130_fd_sc_hd__a211o_1
X_2446_ _2389_/A _3202_/Q _2389_/C VGND VGND VPWR VPWR _2446_/X sky130_fd_sc_hd__a21bo_1
X_2377_ _2585_/A VGND VGND VPWR VPWR _2377_/Y sky130_fd_sc_hd__inv_2
XFILLER_56_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_369 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2300_ _3188_/Q _2129_/X _2296_/X _2299_/X VGND VGND VPWR VPWR _3188_/D sky130_fd_sc_hd__o22a_1
X_3280_ _3287_/CLK _3280_/D VGND VGND VPWR VPWR _3280_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2231_ _2733_/A _2090_/X _2230_/X _2247_/D VGND VGND VPWR VPWR _2231_/X sky130_fd_sc_hd__a31o_1
XTAP_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2162_ _2162_/A VGND VGND VPWR VPWR _2162_/X sky130_fd_sc_hd__clkbuf_8
X_2093_ _1611_/Y _1871_/B _2630_/B _2091_/C VGND VGND VPWR VPWR _2093_/X sky130_fd_sc_hd__o211a_1
XFILLER_21_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2995_ _3055_/A _3184_/Q VGND VGND VPWR VPWR _2995_/X sky130_fd_sc_hd__or2_1
XFILLER_21_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1946_ _2726_/A _2520_/A _2520_/B _2492_/D VGND VGND VPWR VPWR _1955_/A sky130_fd_sc_hd__a31o_1
X_1877_ _1863_/Y _1872_/X _1874_/Y _1876_/X VGND VGND VPWR VPWR _3132_/D sky130_fd_sc_hd__a31o_1
X_2429_ _3203_/Q _2086_/B _3201_/Q VGND VGND VPWR VPWR _2430_/A sky130_fd_sc_hd__o21ai_1
XFILLER_28_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1800_ _1771_/Y _1772_/X _1780_/Y _1785_/X _1799_/Y VGND VGND VPWR VPWR _1827_/C
+ sky130_fd_sc_hd__o2111a_1
X_2780_ _3310_/Q _2747_/X _2779_/X VGND VGND VPWR VPWR _3310_/D sky130_fd_sc_hd__a21o_1
X_1731_ _3232_/Q _1740_/B _1740_/C VGND VGND VPWR VPWR _1731_/X sky130_fd_sc_hd__and3_1
X_1662_ _2424_/A _2434_/B _2520_/B VGND VGND VPWR VPWR _1665_/A sky130_fd_sc_hd__and3_1
X_3401_ _3407_/CLK _3401_/D VGND VGND VPWR VPWR _3401_/Q sky130_fd_sc_hd__dfxtp_1
X_3332_ _3404_/CLK _3332_/D VGND VGND VPWR VPWR _3332_/Q sky130_fd_sc_hd__dfxtp_1
X_1593_ _3251_/Q VGND VGND VPWR VPWR _2740_/A sky130_fd_sc_hd__buf_12
XTAP_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3263_ _3266_/CLK _3263_/D VGND VGND VPWR VPWR _3263_/Q sky130_fd_sc_hd__dfxtp_2
XTAP_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2214_ _2389_/C input23/X _2213_/X VGND VGND VPWR VPWR _2214_/X sky130_fd_sc_hd__o21a_1
X_3194_ _3194_/CLK _3194_/D VGND VGND VPWR VPWR _3194_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_38_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2145_ _2188_/B _3172_/Q _2161_/B _2120_/B VGND VGND VPWR VPWR _2145_/X sky130_fd_sc_hd__a31o_1
XFILLER_26_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2076_ _2494_/A _2076_/B _3122_/C _2076_/D VGND VGND VPWR VPWR _2076_/X sky130_fd_sc_hd__or4_1
XFILLER_53_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2978_ _2832_/A _3178_/Q _2977_/X _2816_/X VGND VGND VPWR VPWR _2978_/X sky130_fd_sc_hd__o211a_1
X_1929_ _3156_/Q _3153_/Q _3330_/Q VGND VGND VPWR VPWR _1929_/X sky130_fd_sc_hd__mux2_1
XFILLER_30_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_100 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_147 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_350 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2901_ _2837_/A _2899_/Y _2903_/C VGND VGND VPWR VPWR _3368_/D sky130_fd_sc_hd__mux2_1
XFILLER_43_191 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2832_ _2832_/A _2851_/A _2851_/B _2851_/C VGND VGND VPWR VPWR _2832_/X sky130_fd_sc_hd__or4_1
X_2763_ _3298_/Q _2888_/S _2762_/X VGND VGND VPWR VPWR _3298_/D sky130_fd_sc_hd__o21a_1
X_1714_ _2020_/B _1715_/C _2020_/D _3242_/Q VGND VGND VPWR VPWR _1716_/A sky130_fd_sc_hd__a31o_1
X_2694_ _3256_/Q input27/X _2717_/S VGND VGND VPWR VPWR _3256_/D sky130_fd_sc_hd__mux2_1
XFILLER_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1645_ _2851_/B _2448_/A VGND VGND VPWR VPWR _2424_/D sky130_fd_sc_hd__nor2_1
X_1576_ _1576_/A VGND VGND VPWR VPWR _2838_/A sky130_fd_sc_hd__clkbuf_4
X_3315_ _3356_/CLK _3315_/D VGND VGND VPWR VPWR _3315_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_228 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3246_ _3365_/CLK _3246_/D VGND VGND VPWR VPWR _3246_/Q sky130_fd_sc_hd__dfxtp_4
XTAP_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3177_ _3391_/CLK _3177_/D VGND VGND VPWR VPWR _3177_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_39_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2128_ _2128_/A _2128_/B _2128_/C _2128_/D VGND VGND VPWR VPWR _2129_/A sky130_fd_sc_hd__and4_1
XFILLER_14_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2059_ _2052_/X _2051_/X _2550_/B _2059_/D VGND VGND VPWR VPWR _2059_/X sky130_fd_sc_hd__and4bb_1
XFILLER_81_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_257 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_92 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput91 _3298_/Q VGND VGND VPWR VPWR o_wb_data[28] sky130_fd_sc_hd__clkbuf_1
Xoutput80 _3295_/Q VGND VGND VPWR VPWR o_wb_data[18] sky130_fd_sc_hd__clkbuf_1
X_3100_ _3100_/A _3100_/B VGND VGND VPWR VPWR _3100_/X sky130_fd_sc_hd__xor2_1
X_3031_ _3055_/A _3190_/Q VGND VGND VPWR VPWR _3031_/X sky130_fd_sc_hd__or2_1
XFILLER_48_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_139 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2815_ _2895_/A _2825_/B VGND VGND VPWR VPWR _2816_/A sky130_fd_sc_hd__nor2_2
XFILLER_11_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2746_ _2746_/A _2746_/B _2743_/C _2743_/D VGND VGND VPWR VPWR _2747_/A sky130_fd_sc_hd__or4bb_2
X_2677_ _2612_/B _2612_/D _2056_/C _2668_/A VGND VGND VPWR VPWR _2677_/X sky130_fd_sc_hd__a31o_1
X_1628_ _3228_/Q VGND VGND VPWR VPWR _2585_/A sky130_fd_sc_hd__clkbuf_16
XTAP_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3229_ _3388_/CLK _3229_/D VGND VGND VPWR VPWR _3229_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_27_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2600_ _1661_/A _1945_/B _2598_/Y _2599_/X VGND VGND VPWR VPWR _2600_/Y sky130_fd_sc_hd__a22oi_1
X_2531_ _3222_/Q _2533_/D _3221_/Q _2078_/X _2530_/Y VGND VGND VPWR VPWR _3222_/D
+ sky130_fd_sc_hd__o311ai_1
XFILLER_5_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2462_ _2458_/X _2459_/X _2461_/X _2097_/A VGND VGND VPWR VPWR _3203_/D sky130_fd_sc_hd__a2bb2oi_1
X_2393_ _2441_/A _3248_/Q VGND VGND VPWR VPWR _2393_/X sky130_fd_sc_hd__or2_2
X_3014_ _2832_/A _3184_/Q _3013_/X _2816_/X VGND VGND VPWR VPWR _3014_/X sky130_fd_sc_hd__o211a_1
XFILLER_36_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2729_ _2039_/B _2727_/Y _2728_/X _3288_/Q _2612_/B VGND VGND VPWR VPWR _2729_/X
+ sky130_fd_sc_hd__o311a_1
XFILLER_59_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_415 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_2_0__f_i_clk clkbuf_0_i_clk/X VGND VGND VPWR VPWR clkbuf_leaf_1_i_clk/A sky130_fd_sc_hd__clkbuf_16
XFILLER_77_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1962_ _2726_/A _2424_/A _1994_/B VGND VGND VPWR VPWR _1962_/X sky130_fd_sc_hd__or3_1
X_1893_ _3138_/Q _3135_/Q _2884_/S VGND VGND VPWR VPWR _1893_/X sky130_fd_sc_hd__mux2_1
X_2514_ _2520_/C _2411_/B _2102_/D _3263_/Q _1656_/X VGND VGND VPWR VPWR _2514_/X
+ sky130_fd_sc_hd__o311a_1
X_2445_ _3201_/Q _2454_/S _2444_/Y VGND VGND VPWR VPWR _3201_/D sky130_fd_sc_hd__a21o_1
X_2376_ _3196_/Q _2247_/D _2367_/X _2375_/X VGND VGND VPWR VPWR _3196_/D sky130_fd_sc_hd__a22o_1
XFILLER_71_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_267 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2230_ _2389_/C input6/X _2229_/X VGND VGND VPWR VPWR _2230_/X sky130_fd_sc_hd__o21a_1
XFILLER_31_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2161_ _2494_/B _2161_/B _2188_/B VGND VGND VPWR VPWR _2162_/A sky130_fd_sc_hd__and3_1
XFILLER_38_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2092_ _2644_/D _2739_/A VGND VGND VPWR VPWR _2630_/B sky130_fd_sc_hd__nand2_2
XFILLER_0_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2994_ _3384_/Q _3381_/Q _3093_/A VGND VGND VPWR VPWR _2994_/X sky130_fd_sc_hd__mux2_1
X_1945_ _2424_/A _1945_/B _2434_/B _2448_/A VGND VGND VPWR VPWR _2492_/D sky130_fd_sc_hd__and4_1
XFILLER_9_94 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1876_ _2520_/C _2384_/C _2520_/A _1875_/X _3132_/Q VGND VGND VPWR VPWR _1876_/X
+ sky130_fd_sc_hd__a32o_1
X_2428_ _2428_/A _2428_/B _2626_/B VGND VGND VPWR VPWR _2454_/S sky130_fd_sc_hd__nand3_2
X_2359_ _2456_/B _2341_/C _2358_/X _2741_/C _3244_/Q VGND VGND VPWR VPWR _2359_/X
+ sky130_fd_sc_hd__o32a_1
XFILLER_29_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_44 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1730_ _1730_/A _1730_/B VGND VGND VPWR VPWR _1730_/Y sky130_fd_sc_hd__nand2_1
X_1661_ _1661_/A _2384_/C _2740_/A VGND VGND VPWR VPWR _1661_/X sky130_fd_sc_hd__and3_1
X_3400_ _3407_/CLK _3400_/D VGND VGND VPWR VPWR _3400_/Q sky130_fd_sc_hd__dfxtp_1
X_1592_ _2043_/B VGND VGND VPWR VPWR _2448_/B sky130_fd_sc_hd__buf_12
X_3331_ _3345_/CLK _3331_/D VGND VGND VPWR VPWR _3331_/Q sky130_fd_sc_hd__dfxtp_4
XTAP_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3262_ _3266_/CLK _3262_/D VGND VGND VPWR VPWR _3262_/Q sky130_fd_sc_hd__dfxtp_2
XTAP_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2213_ _2389_/A _3179_/Q _2441_/A VGND VGND VPWR VPWR _2213_/X sky130_fd_sc_hd__a21bo_1
XTAP_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3193_ _3204_/CLK _3193_/D VGND VGND VPWR VPWR _3193_/Q sky130_fd_sc_hd__dfxtp_2
X_2144_ _2389_/A _3172_/Q _2389_/C VGND VGND VPWR VPWR _2144_/X sky130_fd_sc_hd__a21bo_1
XFILLER_53_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2075_ _2448_/B _2075_/B VGND VGND VPWR VPWR _3122_/C sky130_fd_sc_hd__nor2_1
XFILLER_61_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2977_ _3055_/A _3181_/Q VGND VGND VPWR VPWR _2977_/X sky130_fd_sc_hd__or2_1
X_1928_ _3156_/Q _1927_/X _1932_/S VGND VGND VPWR VPWR _3156_/D sky130_fd_sc_hd__mux2_1
XFILLER_30_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1859_ _2740_/A VGND VGND VPWR VPWR _2335_/A sky130_fd_sc_hd__buf_12
XFILLER_39_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_145 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_80 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2900_ _2896_/C _2895_/C _2897_/X VGND VGND VPWR VPWR _2903_/C sky130_fd_sc_hd__a21oi_1
XFILLER_50_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2831_ _3084_/S VGND VGND VPWR VPWR _2831_/Y sky130_fd_sc_hd__inv_2
X_2762_ _3362_/Q _2801_/C _2745_/X _2658_/C _2747_/X VGND VGND VPWR VPWR _2762_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_77_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1713_ _1709_/Y _1710_/Y _1791_/A _1701_/X input9/X VGND VGND VPWR VPWR _1713_/X
+ sky130_fd_sc_hd__o311a_1
X_2693_ _2520_/C _2641_/Y _2690_/X _2692_/X VGND VGND VPWR VPWR _3255_/D sky130_fd_sc_hd__o22ai_1
X_1644_ _1644_/A VGND VGND VPWR VPWR _1644_/X sky130_fd_sc_hd__buf_8
X_1575_ _2851_/B _2851_/A VGND VGND VPWR VPWR _1576_/A sky130_fd_sc_hd__or2_1
X_3314_ _3350_/CLK _3314_/D VGND VGND VPWR VPWR _3314_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3245_ _3365_/CLK _3245_/D VGND VGND VPWR VPWR _3245_/Q sky130_fd_sc_hd__dfxtp_2
XTAP_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3176_ _3194_/CLK _3176_/D VGND VGND VPWR VPWR _3176_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_39_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2127_ _3257_/Q _2552_/A _2123_/X _3170_/Q _2126_/X VGND VGND VPWR VPWR _3170_/D
+ sky130_fd_sc_hd__a221o_1
XFILLER_26_104 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2058_ _2056_/X _2612_/D _2612_/B _1947_/X _2057_/X VGND VGND VPWR VPWR _2059_/D
+ sky130_fd_sc_hd__a311oi_1
XFILLER_54_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput70 _3131_/Q VGND VGND VPWR VPWR o_wb_ack sky130_fd_sc_hd__clkbuf_1
Xoutput92 _3299_/Q VGND VGND VPWR VPWR o_wb_data[29] sky130_fd_sc_hd__clkbuf_1
Xoutput81 _3296_/Q VGND VGND VPWR VPWR o_wb_data[19] sky130_fd_sc_hd__clkbuf_1
X_3030_ _3390_/Q _3387_/Q _3093_/A VGND VGND VPWR VPWR _3030_/X sky130_fd_sc_hd__mux2_1
XFILLER_63_210 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2814_ _2814_/A VGND VGND VPWR VPWR _2825_/B sky130_fd_sc_hd__buf_2
X_2745_ _2448_/B _2616_/C _1630_/Y _1647_/X VGND VGND VPWR VPWR _2745_/X sky130_fd_sc_hd__a22o_4
X_2676_ _2434_/B _2641_/Y _2675_/X _2692_/C VGND VGND VPWR VPWR _3253_/D sky130_fd_sc_hd__o22a_1
X_1627_ _3249_/Q VGND VGND VPWR VPWR _2188_/A sky130_fd_sc_hd__buf_8
XTAP_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3228_ _3228_/CLK _3228_/D VGND VGND VPWR VPWR _3228_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_36_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3159_ _3365_/CLK _3159_/D VGND VGND VPWR VPWR _3159_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_14_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2530_ _3221_/Q _2533_/D _3222_/Q VGND VGND VPWR VPWR _2530_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_61_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2461_ _2460_/X _2492_/C _1959_/Y _2459_/A _2458_/X VGND VGND VPWR VPWR _2461_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_3_30 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2392_ _2389_/A _3198_/Q _2441_/A VGND VGND VPWR VPWR _2392_/X sky130_fd_sc_hd__a21bo_1
X_3013_ _3055_/A _3187_/Q VGND VGND VPWR VPWR _3013_/X sky130_fd_sc_hd__or2_1
XFILLER_24_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_202 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2728_ _1998_/C _2575_/S _2576_/C _2613_/C VGND VGND VPWR VPWR _2728_/X sky130_fd_sc_hd__o2bb2a_1
X_2659_ _2188_/A _2377_/Y _1676_/Y _1679_/B _2463_/C VGND VGND VPWR VPWR _2659_/X
+ sky130_fd_sc_hd__o2111a_1
XFILLER_59_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_408 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1961_ _2448_/A _2424_/A _2434_/B _2726_/B VGND VGND VPWR VPWR _1964_/B sky130_fd_sc_hd__or4_2
X_1892_ _3138_/Q _1891_/X _1932_/S VGND VGND VPWR VPWR _3138_/D sky130_fd_sc_hd__mux2_1
X_2513_ _3216_/Q _2497_/Y _2512_/X _2078_/X VGND VGND VPWR VPWR _3216_/D sky130_fd_sc_hd__o211a_1
X_2444_ _2543_/C _2443_/X _2454_/S VGND VGND VPWR VPWR _2444_/Y sky130_fd_sc_hd__a21oi_1
X_2375_ _2594_/B _3122_/A _2164_/X input13/X _2374_/X VGND VGND VPWR VPWR _2375_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_68_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2160_ _3173_/Q _2129_/X _2159_/X VGND VGND VPWR VPWR _3173_/D sky130_fd_sc_hd__o21a_1
XFILLER_65_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2091_ _2644_/D _2739_/A _2091_/C VGND VGND VPWR VPWR _2091_/X sky130_fd_sc_hd__and3_1
XFILLER_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2993_ _3384_/Q _2906_/X _2992_/X VGND VGND VPWR VPWR _3384_/D sky130_fd_sc_hd__a21o_1
X_1944_ _2577_/D _2102_/D VGND VGND VPWR VPWR _1945_/B sky130_fd_sc_hd__nand2_1
X_1875_ _2318_/A _2434_/B _2384_/C _1956_/B _2494_/C VGND VGND VPWR VPWR _1875_/X
+ sky130_fd_sc_hd__a41o_1
XFILLER_0_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2427_ _2613_/B _2423_/X _2426_/X _2128_/A VGND VGND VPWR VPWR _2428_/A sky130_fd_sc_hd__o211a_1
XFILLER_28_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2358_ _2318_/A _3282_/Q _1644_/X _2357_/X _2312_/X VGND VGND VPWR VPWR _2358_/X
+ sky130_fd_sc_hd__a32o_1
X_2289_ _3187_/Q _2129_/X _2285_/X _2288_/X VGND VGND VPWR VPWR _3187_/D sky130_fd_sc_hd__o22a_1
XFILLER_52_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_231 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1660_ _3255_/Q _2448_/D VGND VGND VPWR VPWR _1661_/A sky130_fd_sc_hd__nor2_8
X_1591_ _3252_/Q VGND VGND VPWR VPWR _2043_/B sky130_fd_sc_hd__buf_12
X_3330_ _3330_/CLK _3330_/D VGND VGND VPWR VPWR _3330_/Q sky130_fd_sc_hd__dfxtp_4
XTAP_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3261_ _3266_/CLK _3261_/D VGND VGND VPWR VPWR _3261_/Q sky130_fd_sc_hd__dfxtp_2
XTAP_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3192_ _3194_/CLK _3192_/D VGND VGND VPWR VPWR _3192_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_22_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2212_ _3179_/Q _2162_/X _2164_/X input5/X _2211_/X VGND VGND VPWR VPWR _2212_/X
+ sky130_fd_sc_hd__a221o_1
XTAP_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2143_ _2739_/A _2604_/A VGND VGND VPWR VPWR _2143_/X sky130_fd_sc_hd__or2_1
XFILLER_66_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2074_ _2335_/A _2851_/B _2552_/C _1854_/Y _2448_/B VGND VGND VPWR VPWR _2076_/B
+ sky130_fd_sc_hd__a32o_1
XFILLER_14_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2976_ _3381_/Q _3378_/Q _3093_/A VGND VGND VPWR VPWR _2976_/X sky130_fd_sc_hd__mux2_1
X_1927_ _3155_/Q _3152_/Q _2884_/S VGND VGND VPWR VPWR _1927_/X sky130_fd_sc_hd__mux2_1
X_1858_ _2644_/D _2740_/B VGND VGND VPWR VPWR _1858_/X sky130_fd_sc_hd__or2_2
X_1789_ _1786_/X _1788_/Y input7/X VGND VGND VPWR VPWR _1789_/Y sky130_fd_sc_hd__o21bai_1
XFILLER_76_208 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2830_ _2828_/Y _2821_/X _3325_/Q _2829_/Y VGND VGND VPWR VPWR _3325_/D sky130_fd_sc_hd__a2bb2o_1
XFILLER_31_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2761_ _3297_/Q _2888_/S _2760_/X VGND VGND VPWR VPWR _3297_/D sky130_fd_sc_hd__o21a_1
X_1712_ _1815_/B _1815_/C _1809_/C VGND VGND VPWR VPWR _1791_/A sky130_fd_sc_hd__or3_1
X_2692_ _2692_/A _2692_/B _2692_/C VGND VGND VPWR VPWR _2692_/X sky130_fd_sc_hd__or3_1
XFILLER_6_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1643_ _2424_/A _1851_/C _2043_/B _2434_/B VGND VGND VPWR VPWR _1644_/A sky130_fd_sc_hd__and4b_1
XANTENNA_1 _2290_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1574_ _3333_/Q VGND VGND VPWR VPWR _2851_/B sky130_fd_sc_hd__buf_8
X_3313_ _3350_/CLK _3313_/D VGND VGND VPWR VPWR _3313_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3244_ _3365_/CLK _3244_/D VGND VGND VPWR VPWR _3244_/Q sky130_fd_sc_hd__dfxtp_4
XTAP_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3175_ _3391_/CLK _3175_/D VGND VGND VPWR VPWR _3175_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_81_211 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2126_ _3170_/Q _2494_/B _2389_/A _2188_/B VGND VGND VPWR VPWR _2126_/X sky130_fd_sc_hd__and4_1
XFILLER_26_116 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2057_ _2318_/A _2520_/A _2520_/B _1992_/X VGND VGND VPWR VPWR _2057_/X sky130_fd_sc_hd__a31o_1
XPHY_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2959_ _3055_/A _3178_/Q VGND VGND VPWR VPWR _2959_/X sky130_fd_sc_hd__or2_1
XFILLER_17_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput93 _3303_/Q VGND VGND VPWR VPWR o_wb_data[2] sky130_fd_sc_hd__clkbuf_1
Xoutput82 _3302_/Q VGND VGND VPWR VPWR o_wb_data[1] sky130_fd_sc_hd__clkbuf_1
Xoutput71 _3301_/Q VGND VGND VPWR VPWR o_wb_data[0] sky130_fd_sc_hd__clkbuf_1
XFILLER_0_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2813_ _2889_/B _2837_/A _2813_/C VGND VGND VPWR VPWR _2814_/A sky130_fd_sc_hd__and3b_1
XFILLER_31_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2744_ _2744_/A VGND VGND VPWR VPWR _2888_/S sky130_fd_sc_hd__buf_6
XFILLER_8_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2675_ _1872_/B _2353_/Y _2664_/Y _2673_/X _2674_/X VGND VGND VPWR VPWR _2675_/X
+ sky130_fd_sc_hd__o32a_1
X_1626_ _2726_/A _2424_/A _2434_/B _2114_/D VGND VGND VPWR VPWR _1626_/X sky130_fd_sc_hd__or4_4
XTAP_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3227_ _3409_/CLK _3227_/D VGND VGND VPWR VPWR _3227_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_39_252 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3158_ _3363_/CLK _3158_/D VGND VGND VPWR VPWR _3158_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_36_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2109_ _2109_/A _2456_/D _2109_/C VGND VGND VPWR VPWR _3123_/B sky130_fd_sc_hd__or3_1
XFILLER_54_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3089_ _3400_/Q _2906_/A _3088_/X VGND VGND VPWR VPWR _3400_/D sky130_fd_sc_hd__a21o_1
XFILLER_14_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_211 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2460_ _3165_/Q _2851_/B VGND VGND VPWR VPWR _2460_/X sky130_fd_sc_hd__or2_2
X_2391_ _3197_/Q _2247_/D _2387_/X _2390_/X VGND VGND VPWR VPWR _3197_/D sky130_fd_sc_hd__a22o_1
XFILLER_68_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_42 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_68_325 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3012_ _3387_/Q _3384_/Q _3093_/A VGND VGND VPWR VPWR _3012_/X sky130_fd_sc_hd__mux2_1
XFILLER_36_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2727_ _3331_/Q _1656_/X _2741_/B _2594_/B _2738_/B VGND VGND VPWR VPWR _2727_/Y
+ sky130_fd_sc_hd__o221ai_1
X_2658_ _3203_/Q _2658_/B _2658_/C VGND VGND VPWR VPWR _2658_/X sky130_fd_sc_hd__and3_1
X_2589_ _2851_/A _3200_/Q _2459_/A _3055_/A _1661_/X VGND VGND VPWR VPWR _2589_/X
+ sky130_fd_sc_hd__o311a_1
X_1609_ _2604_/A input5/X VGND VGND VPWR VPWR _1610_/A sky130_fd_sc_hd__or2_1
XFILLER_27_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_380 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1960_ _1960_/A _2456_/D _2051_/B _1959_/Y VGND VGND VPWR VPWR _2613_/C sky130_fd_sc_hd__or4b_2
X_1891_ _3137_/Q _3134_/Q _2884_/S VGND VGND VPWR VPWR _1891_/X sky130_fd_sc_hd__mux2_1
X_2512_ _3338_/Q _2110_/C _2511_/X _2499_/X VGND VGND VPWR VPWR _2512_/X sky130_fd_sc_hd__a211o_1
XFILLER_52_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2443_ _1872_/B _2432_/X _2440_/X _2442_/Y VGND VGND VPWR VPWR _2443_/X sky130_fd_sc_hd__a2bb2o_1
X_2374_ _2448_/B _2369_/X _2335_/A _2494_/B _2373_/X VGND VGND VPWR VPWR _2374_/X
+ sky130_fd_sc_hd__o32a_1
XFILLER_68_111 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_83 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2090_ _2090_/A VGND VGND VPWR VPWR _2090_/X sky130_fd_sc_hd__buf_6
XFILLER_48_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2992_ _3184_/Q _2907_/X _2909_/X _2991_/X VGND VGND VPWR VPWR _2992_/X sky130_fd_sc_hd__o211a_1
XFILLER_14_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1943_ _2318_/A _2411_/B _2577_/D _3331_/Q VGND VGND VPWR VPWR _1943_/X sky130_fd_sc_hd__o31a_1
XFILLER_9_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1874_ _2389_/C _2086_/B _1608_/X _2494_/C _1623_/X VGND VGND VPWR VPWR _1874_/Y
+ sky130_fd_sc_hd__a311oi_1
X_2426_ _2335_/A _2741_/B _2066_/X _2547_/B _2425_/X VGND VGND VPWR VPWR _2426_/X
+ sky130_fd_sc_hd__o2111a_1
XFILLER_69_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2357_ _2368_/B _2368_/C _2658_/B VGND VGND VPWR VPWR _2357_/X sky130_fd_sc_hd__a21o_1
X_2288_ _2733_/A _2090_/X _2287_/X _2247_/D VGND VGND VPWR VPWR _2288_/X sky130_fd_sc_hd__a31o_1
XFILLER_44_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1590_ _2448_/A VGND VGND VPWR VPWR _2520_/C sky130_fd_sc_hd__clkbuf_16
XTAP_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3260_ _3404_/CLK _3260_/D VGND VGND VPWR VPWR _3260_/Q sky130_fd_sc_hd__dfxtp_2
XTAP_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3191_ _3194_/CLK _3191_/D VGND VGND VPWR VPWR _3191_/Q sky130_fd_sc_hd__dfxtp_1
X_2211_ _2520_/C _2585_/A _1644_/X _2210_/X VGND VGND VPWR VPWR _2211_/X sky130_fd_sc_hd__a31o_1
XTAP_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2142_ _3171_/Q _2129_/X _2141_/X VGND VGND VPWR VPWR _3171_/D sky130_fd_sc_hd__o21a_1
XFILLER_15_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2073_ _2073_/A VGND VGND VPWR VPWR _2552_/C sky130_fd_sc_hd__buf_4
XFILLER_81_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2975_ _3381_/Q _2906_/X _2974_/X VGND VGND VPWR VPWR _3381_/D sky130_fd_sc_hd__a21o_1
X_1926_ _3155_/Q _1925_/X _1932_/S VGND VGND VPWR VPWR _3155_/D sky130_fd_sc_hd__mux2_1
XFILLER_30_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1857_ _1847_/Y _1852_/X _1856_/X VGND VGND VPWR VPWR _1857_/Y sky130_fd_sc_hd__a21oi_1
X_1788_ _2020_/B _1787_/X _3239_/Q VGND VGND VPWR VPWR _1788_/Y sky130_fd_sc_hd__a21oi_1
XFILLER_39_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3389_ _3389_/CLK _3389_/D VGND VGND VPWR VPWR _3389_/Q sky130_fd_sc_hd__dfxtp_1
X_2409_ _2318_/A _2520_/A _2436_/C _2408_/X VGND VGND VPWR VPWR _2409_/X sky130_fd_sc_hd__a31o_1
XFILLER_69_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_37 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_264 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2760_ _3361_/Q _2801_/C _2745_/X _3248_/Q _2747_/X VGND VGND VPWR VPWR _2760_/X
+ sky130_fd_sc_hd__a221o_1
X_1711_ _3236_/Q _3237_/Q _3238_/Q _3239_/Q VGND VGND VPWR VPWR _1809_/C sky130_fd_sc_hd__nand4_4
X_2691_ _2616_/B _2664_/Y _3122_/A _2594_/B VGND VGND VPWR VPWR _2692_/B sky130_fd_sc_hd__o211a_1
X_1642_ _2424_/A _2434_/B _2436_/C _2448_/A VGND VGND VPWR VPWR _2575_/S sky130_fd_sc_hd__and4_4
XANTENNA_2 _2114_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1573_ _2889_/B _1573_/B VGND VGND VPWR VPWR _2838_/B sky130_fd_sc_hd__nor2_2
XFILLER_6_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3312_ _3350_/CLK _3312_/D VGND VGND VPWR VPWR _3312_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3243_ _3365_/CLK _3243_/D VGND VGND VPWR VPWR _3243_/Q sky130_fd_sc_hd__dfxtp_4
XTAP_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3174_ _3194_/CLK _3174_/D VGND VGND VPWR VPWR _3174_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_39_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2125_ _3256_/Q _2552_/A _2123_/X _3169_/Q _2124_/X VGND VGND VPWR VPWR _3169_/D
+ sky130_fd_sc_hd__a221o_1
XFILLER_26_128 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2056_ _3165_/Q _3131_/Q _2056_/C _1858_/X VGND VGND VPWR VPWR _2056_/X sky130_fd_sc_hd__or4b_1
X_2958_ _3378_/Q _3375_/Q _3093_/A VGND VGND VPWR VPWR _2958_/X sky130_fd_sc_hd__mux2_1
XFILLER_22_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1909_ _3146_/Q _3143_/Q _2884_/S VGND VGND VPWR VPWR _1909_/X sky130_fd_sc_hd__mux2_1
X_2889_ _2889_/A _2889_/B VGND VGND VPWR VPWR _2889_/Y sky130_fd_sc_hd__nand2_1
XFILLER_72_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput61 _3164_/Q VGND VGND VPWR VPWR o_interrupt sky130_fd_sc_hd__clkbuf_1
Xoutput94 _3300_/Q VGND VGND VPWR VPWR o_wb_data[30] sky130_fd_sc_hd__clkbuf_1
Xoutput83 _3315_/Q VGND VGND VPWR VPWR o_wb_data[20] sky130_fd_sc_hd__clkbuf_1
Xoutput72 _3311_/Q VGND VGND VPWR VPWR o_wb_data[10] sky130_fd_sc_hd__clkbuf_1
XFILLER_0_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_120 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2812_ _2837_/A _2889_/B _2813_/C VGND VGND VPWR VPWR _2895_/A sky130_fd_sc_hd__nor3_4
XFILLER_31_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2743_ _2746_/A _2746_/B _2743_/C _2743_/D VGND VGND VPWR VPWR _2744_/A sky130_fd_sc_hd__and4bb_1
X_2674_ _2494_/B _2463_/C _1676_/Y _2368_/C _3122_/A VGND VGND VPWR VPWR _2674_/X
+ sky130_fd_sc_hd__a41o_1
X_1625_ _2043_/B _2740_/A VGND VGND VPWR VPWR _2114_/D sky130_fd_sc_hd__nand2_4
XTAP_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3226_ _3266_/CLK _3226_/D VGND VGND VPWR VPWR _3226_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_264 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3157_ _3363_/CLK _3157_/D VGND VGND VPWR VPWR _3157_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_27_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2108_ _2448_/B _2492_/A _2492_/B _2492_/C VGND VGND VPWR VPWR _2109_/C sky130_fd_sc_hd__a211o_1
XFILLER_54_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3088_ _3200_/Q _2907_/A _2909_/A _3087_/X VGND VGND VPWR VPWR _3088_/X sky130_fd_sc_hd__o211a_1
X_2039_ _2039_/A _2039_/B _2038_/X VGND VGND VPWR VPWR _2039_/X sky130_fd_sc_hd__or3b_1
XFILLER_6_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_79 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2390_ _1872_/B _2388_/X _2389_/X _2129_/X VGND VGND VPWR VPWR _2390_/X sky130_fd_sc_hd__o31a_1
XFILLER_3_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3011_ _3387_/Q _2906_/X _3010_/X VGND VGND VPWR VPWR _3387_/D sky130_fd_sc_hd__a21o_1
XFILLER_36_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2726_ _2726_/A _2726_/B _2726_/C _2726_/D VGND VGND VPWR VPWR _2738_/B sky130_fd_sc_hd__or4_1
X_2657_ _2657_/A _2657_/B _2657_/C _2657_/D VGND VGND VPWR VPWR _2657_/X sky130_fd_sc_hd__or4_1
X_1608_ _1608_/A VGND VGND VPWR VPWR _1608_/X sky130_fd_sc_hd__buf_6
X_2588_ _2594_/B _2120_/B _2587_/X _1626_/X VGND VGND VPWR VPWR _2588_/X sky130_fd_sc_hd__o211a_1
XFILLER_59_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_359 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3209_ _3353_/CLK _3209_/D VGND VGND VPWR VPWR _3209_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_27_212 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1890_ _3137_/Q _1889_/X _1932_/S VGND VGND VPWR VPWR _3137_/D sky130_fd_sc_hd__mux2_1
X_2511_ _2520_/C _2411_/B _2102_/D _3260_/Q _1656_/X VGND VGND VPWR VPWR _2511_/X
+ sky130_fd_sc_hd__o311a_1
X_2442_ _2594_/B _2664_/B _3122_/A VGND VGND VPWR VPWR _2442_/Y sky130_fd_sc_hd__o21ai_1
X_2373_ _2370_/X _2341_/C _2372_/X _2741_/C _3245_/Q VGND VGND VPWR VPWR _2373_/X
+ sky130_fd_sc_hd__o32a_1
XFILLER_68_123 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2709_ _3271_/Q input33/X _2717_/S VGND VGND VPWR VPWR _3271_/D sky130_fd_sc_hd__mux2_1
XFILLER_3_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_92 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2991_ _2988_/X _2826_/X _3100_/A _2990_/X VGND VGND VPWR VPWR _2991_/X sky130_fd_sc_hd__a211o_1
X_1942_ _3163_/Q _1941_/X _1942_/S VGND VGND VPWR VPWR _3163_/D sky130_fd_sc_hd__mux2_1
X_1873_ _2726_/C _1873_/B _2448_/A _2459_/A VGND VGND VPWR VPWR _2494_/C sky130_fd_sc_hd__and4b_2
X_2425_ _2644_/D _1626_/X _2733_/A _2424_/X _2120_/X VGND VGND VPWR VPWR _2425_/X
+ sky130_fd_sc_hd__o311a_1
X_2356_ _3195_/Q _1987_/Y _2389_/C VGND VGND VPWR VPWR _2356_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_69_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2287_ _2389_/C input12/X _2286_/X VGND VGND VPWR VPWR _2287_/X sky130_fd_sc_hd__o21a_1
XFILLER_56_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_332 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_340 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_384 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_107 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_72 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2210_ _3236_/Q _2207_/X _2208_/X _2209_/X VGND VGND VPWR VPWR _2210_/X sky130_fd_sc_hd__o211a_1
XTAP_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3190_ _3200_/CLK _3190_/D VGND VGND VPWR VPWR _3190_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_59_91 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2141_ _1608_/X _2130_/X _2131_/X _2140_/X _2247_/D VGND VGND VPWR VPWR _2141_/X
+ sky130_fd_sc_hd__a311o_1
XFILLER_66_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2072_ _2424_/A _2384_/C _2434_/B _2726_/A VGND VGND VPWR VPWR _2073_/A sky130_fd_sc_hd__and4b_1
XFILLER_81_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2974_ _3181_/Q _2907_/X _2909_/X _2973_/X VGND VGND VPWR VPWR _2974_/X sky130_fd_sc_hd__o211a_1
X_1925_ _3154_/Q _3151_/Q _2884_/S VGND VGND VPWR VPWR _1925_/X sky130_fd_sc_hd__mux2_1
X_1856_ _1873_/B _1661_/A _1853_/X _2039_/B VGND VGND VPWR VPWR _1856_/X sky130_fd_sc_hd__a31o_1
XFILLER_30_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1787_ _3236_/Q _3237_/Q _3238_/Q VGND VGND VPWR VPWR _1787_/X sky130_fd_sc_hd__and3_1
XFILLER_1_409 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3388_ _3388_/CLK _3388_/D VGND VGND VPWR VPWR _3388_/Q sky130_fd_sc_hd__dfxtp_1
X_2408_ _3286_/Q _2577_/D _2547_/C _2371_/X VGND VGND VPWR VPWR _2408_/X sky130_fd_sc_hd__o31a_1
X_2339_ _2448_/A _2043_/B _2448_/D _1844_/B VGND VGND VPWR VPWR _2339_/X sky130_fd_sc_hd__o31a_1
XFILLER_57_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_192 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2690_ _2685_/X _2044_/X _1872_/B _2689_/Y VGND VGND VPWR VPWR _2690_/X sky130_fd_sc_hd__o211a_1
X_1710_ _3241_/Q VGND VGND VPWR VPWR _1710_/Y sky130_fd_sc_hd__inv_2
X_1641_ _2740_/A _2384_/C VGND VGND VPWR VPWR _2436_/C sky130_fd_sc_hd__nor2_8
XANTENNA_3 input3/X VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3311_ _3350_/CLK _3311_/D VGND VGND VPWR VPWR _3311_/Q sky130_fd_sc_hd__dfxtp_1
X_1572_ _2837_/A _3367_/Q VGND VGND VPWR VPWR _1573_/B sky130_fd_sc_hd__or2_2
XTAP_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3242_ _3365_/CLK _3242_/D VGND VGND VPWR VPWR _3242_/Q sky130_fd_sc_hd__dfxtp_2
X_3173_ _3194_/CLK _3173_/D VGND VGND VPWR VPWR _3173_/Q sky130_fd_sc_hd__dfxtp_2
XTAP_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2124_ _3169_/Q _2494_/B _2389_/A _2188_/B VGND VGND VPWR VPWR _2124_/X sky130_fd_sc_hd__and4_1
XFILLER_54_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2055_ _2055_/A _2055_/B VGND VGND VPWR VPWR _2056_/C sky130_fd_sc_hd__nor2_1
XFILLER_81_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2957_ _3378_/Q _2906_/X _2956_/X VGND VGND VPWR VPWR _3378_/D sky130_fd_sc_hd__a21o_1
X_2888_ _3366_/Q _2887_/X _2888_/S VGND VGND VPWR VPWR _3366_/D sky130_fd_sc_hd__mux2_1
X_1908_ _3146_/Q _1907_/X _1932_/S VGND VGND VPWR VPWR _3146_/D sky130_fd_sc_hd__mux2_1
XFILLER_30_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1839_ _2448_/A _2411_/B VGND VGND VPWR VPWR _2492_/A sky130_fd_sc_hd__nor2_8
XTAP_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput84 _3316_/Q VGND VGND VPWR VPWR o_wb_data[21] sky130_fd_sc_hd__clkbuf_1
Xoutput73 _3312_/Q VGND VGND VPWR VPWR o_wb_data[11] sky130_fd_sc_hd__clkbuf_1
Xoutput62 _2633_/B VGND VGND VPWR VPWR o_qspi_cs_n sky130_fd_sc_hd__clkbuf_1
Xoutput95 _3366_/Q VGND VGND VPWR VPWR o_wb_data[31] sky130_fd_sc_hd__clkbuf_1
XFILLER_0_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_2_3__f_i_clk clkbuf_0_i_clk/X VGND VGND VPWR VPWR _3228_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_31_132 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2811_ _3400_/Q _3397_/Q _3093_/A VGND VGND VPWR VPWR _2811_/X sky130_fd_sc_hd__mux2_1
XFILLER_75_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2742_ _3331_/Q _1656_/X _2738_/X _1668_/X _2741_/X VGND VGND VPWR VPWR _2743_/D
+ sky130_fd_sc_hd__o2111a_1
X_2673_ _2448_/B _2594_/B _1854_/Y _2670_/X _2672_/X VGND VGND VPWR VPWR _2673_/X
+ sky130_fd_sc_hd__a32o_1
X_1624_ _2389_/C _2086_/B _1608_/X _1617_/X _1623_/X VGND VGND VPWR VPWR _1624_/X
+ sky130_fd_sc_hd__a311o_1
X_3225_ _3409_/CLK _3225_/D VGND VGND VPWR VPWR _3225_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3156_ _3363_/CLK _3156_/D VGND VGND VPWR VPWR _3156_/Q sky130_fd_sc_hd__dfxtp_1
X_3087_ _3084_/X _2826_/X _2922_/A _3086_/X VGND VGND VPWR VPWR _3087_/X sky130_fd_sc_hd__a211o_1
XFILLER_27_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2107_ _2448_/B _2740_/A _2313_/C VGND VGND VPWR VPWR _2109_/A sky130_fd_sc_hd__and3_2
XFILLER_42_408 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2038_ _2102_/D _2075_/B _2055_/B _2038_/D VGND VGND VPWR VPWR _2038_/X sky130_fd_sc_hd__or4_1
XFILLER_62_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3010_ _3187_/Q _2907_/X _2909_/X _3009_/X VGND VGND VPWR VPWR _3010_/X sky130_fd_sc_hd__o211a_1
XFILLER_17_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2725_ _3287_/Q _2097_/B _2725_/S VGND VGND VPWR VPWR _3287_/D sky130_fd_sc_hd__mux2_1
X_2656_ _3165_/Q _2851_/B _1656_/X _2650_/X _2655_/Y VGND VGND VPWR VPWR _2657_/D
+ sky130_fd_sc_hd__o32a_1
X_1607_ _3122_/A _2594_/B _2740_/B VGND VGND VPWR VPWR _1608_/A sky130_fd_sc_hd__and3_1
X_2587_ _2586_/X _2042_/X _2120_/B _2726_/B VGND VGND VPWR VPWR _2587_/X sky130_fd_sc_hd__a211o_1
XFILLER_59_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3208_ _3208_/CLK _3208_/D VGND VGND VPWR VPWR _3208_/Q sky130_fd_sc_hd__dfxtp_1
X_3139_ _3343_/CLK _3139_/D VGND VGND VPWR VPWR _3139_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_27_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_260 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_374 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2510_ _3215_/Q _2497_/Y _2509_/X _2078_/X VGND VGND VPWR VPWR _3215_/D sky130_fd_sc_hd__o211a_1
X_2441_ _2441_/A _2733_/A VGND VGND VPWR VPWR _2664_/B sky130_fd_sc_hd__or2b_1
XFILLER_38_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2372_ _3283_/Q _2577_/D _2547_/C _2371_/X VGND VGND VPWR VPWR _2372_/X sky130_fd_sc_hd__o31a_1
XFILLER_68_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_374 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2708_ _3270_/Q input32/X _2717_/S VGND VGND VPWR VPWR _3270_/D sky130_fd_sc_hd__mux2_1
X_2639_ _2639_/A _2692_/C VGND VGND VPWR VPWR _2640_/B sky130_fd_sc_hd__nor2_1
XFILLER_58_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_455 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_138 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2990_ _2832_/A _3180_/Q _2989_/X _2816_/X VGND VGND VPWR VPWR _2990_/X sky130_fd_sc_hd__o211a_1
X_1941_ _3162_/Q _3159_/Q _3330_/Q VGND VGND VPWR VPWR _1941_/X sky130_fd_sc_hd__mux2_1
X_1872_ _2733_/A _1872_/B _1872_/C _1872_/D VGND VGND VPWR VPWR _1872_/X sky130_fd_sc_hd__or4_1
XFILLER_80_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2424_ _2424_/A _2434_/B _2726_/B _2424_/D VGND VGND VPWR VPWR _2424_/X sky130_fd_sc_hd__or4_1
XFILLER_69_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2355_ _3194_/Q _2129_/X _2351_/X _2354_/Y VGND VGND VPWR VPWR _3194_/D sky130_fd_sc_hd__o22a_1
X_2286_ _2389_/A _3187_/Q _2441_/A VGND VGND VPWR VPWR _2286_/X sky130_fd_sc_hd__a21bo_1
XFILLER_37_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_119 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_344 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2140_ _2448_/B _2132_/X _2335_/A _1872_/B _2139_/X VGND VGND VPWR VPWR _2140_/X
+ sky130_fd_sc_hd__o311a_1
X_2071_ _2384_/C _1661_/A _2076_/D VGND VGND VPWR VPWR _2071_/Y sky130_fd_sc_hd__a21oi_1
XFILLER_38_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2973_ _2970_/X _2826_/X _3100_/A _2972_/X VGND VGND VPWR VPWR _2973_/X sky130_fd_sc_hd__a211o_1
X_1924_ _3154_/Q _1923_/X _1932_/S VGND VGND VPWR VPWR _3154_/D sky130_fd_sc_hd__mux2_1
X_1855_ _1599_/C _1994_/B _2520_/C _1854_/Y VGND VGND VPWR VPWR _2039_/B sky130_fd_sc_hd__a31o_1
X_1786_ _1810_/B _1810_/C _2020_/D VGND VGND VPWR VPWR _1786_/X sky130_fd_sc_hd__and3_1
X_3387_ _3388_/CLK _3387_/D VGND VGND VPWR VPWR _3387_/Q sky130_fd_sc_hd__dfxtp_1
X_2407_ _2188_/B _3199_/Q _2161_/B _2120_/B VGND VGND VPWR VPWR _2407_/X sky130_fd_sc_hd__a31o_1
X_2338_ _2384_/C _2594_/B _1661_/A _1955_/C VGND VGND VPWR VPWR _2341_/C sky130_fd_sc_hd__a31o_1
X_2269_ _3185_/Q _2129_/X _2265_/X _2268_/X VGND VGND VPWR VPWR _3185_/D sky130_fd_sc_hd__o22a_1
XFILLER_57_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_303 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1640_ _3165_/Q _2851_/B VGND VGND VPWR VPWR _1998_/C sky130_fd_sc_hd__nor2_4
XANTENNA_4 _3164_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1571_ _2896_/C _2819_/C _2885_/S VGND VGND VPWR VPWR _2806_/S sky130_fd_sc_hd__a21oi_2
X_3310_ _3345_/CLK _3310_/D VGND VGND VPWR VPWR _3310_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3241_ _3365_/CLK _3241_/D VGND VGND VPWR VPWR _3241_/Q sky130_fd_sc_hd__dfxtp_4
XFILLER_20_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3172_ _3398_/CLK _3172_/D VGND VGND VPWR VPWR _3172_/Q sky130_fd_sc_hd__dfxtp_2
XTAP_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2123_ _2389_/C _1608_/X _2389_/A _2247_/D VGND VGND VPWR VPWR _2123_/X sky130_fd_sc_hd__a31o_1
XFILLER_39_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2054_ _1815_/B _1695_/Y _3288_/Q _2733_/A _2739_/A VGND VGND VPWR VPWR _2055_/A
+ sky130_fd_sc_hd__o2111ai_1
XFILLER_34_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2956_ _3178_/Q _2907_/X _2909_/X _2955_/X VGND VGND VPWR VPWR _2956_/X sky130_fd_sc_hd__o211a_1
X_2887_ _2335_/A _3203_/Q _3122_/A _2886_/X VGND VGND VPWR VPWR _2887_/X sky130_fd_sc_hd__a31o_1
X_1907_ _3145_/Q _3142_/Q _2884_/S VGND VGND VPWR VPWR _1907_/X sky130_fd_sc_hd__mux2_1
X_1838_ _1838_/A VGND VGND VPWR VPWR _2411_/B sky130_fd_sc_hd__buf_12
X_1769_ _3246_/Q _2021_/C _2020_/B _1796_/B VGND VGND VPWR VPWR _2027_/A sky130_fd_sc_hd__nand4_1
XTAP_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_200 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_166 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_380 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput85 _3317_/Q VGND VGND VPWR VPWR o_wb_data[22] sky130_fd_sc_hd__clkbuf_1
Xoutput74 _3313_/Q VGND VGND VPWR VPWR o_wb_data[12] sky130_fd_sc_hd__clkbuf_1
Xoutput63 _1583_/X VGND VGND VPWR VPWR o_qspi_dat[0] sky130_fd_sc_hd__clkbuf_1
Xoutput96 _3304_/Q VGND VGND VPWR VPWR o_wb_data[3] sky130_fd_sc_hd__clkbuf_1
XFILLER_48_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_100 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_70 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2810_ _3200_/Q _3197_/Q _3055_/A VGND VGND VPWR VPWR _2810_/X sky130_fd_sc_hd__mux2_1
XFILLER_31_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2741_ _1672_/X _2741_/B _2741_/C _2741_/D VGND VGND VPWR VPWR _2741_/X sky130_fd_sc_hd__and4b_1
XFILLER_8_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2672_ _2832_/A _1853_/X _2075_/B _2102_/D VGND VGND VPWR VPWR _2672_/X sky130_fd_sc_hd__a211o_1
XFILLER_68_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1623_ _1956_/B _2434_/B _2318_/A _2384_/C VGND VGND VPWR VPWR _1623_/X sky130_fd_sc_hd__and4_1
X_3224_ _3266_/CLK _3224_/D VGND VGND VPWR VPWR _3224_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
.ends
