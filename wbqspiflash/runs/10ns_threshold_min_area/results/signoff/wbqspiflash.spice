* NGSPICE file created from wbqspiflash.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_4 abstract view
.subckt sky130_fd_sc_hd__dfxtp_4 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_8 abstract view
.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_4 abstract view
.subckt sky130_fd_sc_hd__mux2_4 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VGND VPWR VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_1 abstract view
.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o41a_1 abstract view
.subckt sky130_fd_sc_hd__o41a_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_1 abstract view
.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_4 abstract view
.subckt sky130_fd_sc_hd__a31oi_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_4 abstract view
.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_1 abstract view
.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_8 abstract view
.subckt sky130_fd_sc_hd__nand2_8 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_8 abstract view
.subckt sky130_fd_sc_hd__nor2_8 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_2 abstract view
.subckt sky130_fd_sc_hd__clkinv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_2 abstract view
.subckt sky130_fd_sc_hd__or4b_2 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_2 abstract view
.subckt sky130_fd_sc_hd__nand4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311oi_1 abstract view
.subckt sky130_fd_sc_hd__a311oi_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_2 abstract view
.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_4 abstract view
.subckt sky130_fd_sc_hd__nand2b_4 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_1 abstract view
.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_4 abstract view
.subckt sky130_fd_sc_hd__or4bb_4 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_1 abstract view
.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_2 abstract view
.subckt sky130_fd_sc_hd__and4_2 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_1 abstract view
.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_1 abstract view
.subckt sky130_fd_sc_hd__a221oi_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_4 abstract view
.subckt sky130_fd_sc_hd__a211oi_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_2 abstract view
.subckt sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111oi_1 abstract view
.subckt sky130_fd_sc_hd__a2111oi_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_4 abstract view
.subckt sky130_fd_sc_hd__nor3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_12 abstract view
.subckt sky130_fd_sc_hd__buf_12 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_1 abstract view
.subckt sky130_fd_sc_hd__or4bb_1 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_1 abstract view
.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_1 abstract view
.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_1 abstract view
.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_4 abstract view
.subckt sky130_fd_sc_hd__inv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_2 abstract view
.subckt sky130_fd_sc_hd__and4bb_2 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_2 abstract view
.subckt sky130_fd_sc_hd__a311o_2 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_1 abstract view
.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_2 abstract view
.subckt sky130_fd_sc_hd__a21o_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_4 abstract view
.subckt sky130_fd_sc_hd__nand3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_2 abstract view
.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_4 abstract view
.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_4 abstract view
.subckt sky130_fd_sc_hd__o211ai_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_1 abstract view
.subckt sky130_fd_sc_hd__nor4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_1 abstract view
.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_4 abstract view
.subckt sky130_fd_sc_hd__o21bai_4 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_1 abstract view
.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_2 abstract view
.subckt sky130_fd_sc_hd__nand2b_2 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_2 abstract view
.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_2 abstract view
.subckt sky130_fd_sc_hd__or4_2 A B C D VGND VNB VPB VPWR X
.ends

.subckt wbqspiflash VGND VPWR i_clk i_qspi_dat[0] i_qspi_dat[1] i_qspi_dat[2] i_qspi_dat[3]
+ i_wb_addr[0] i_wb_addr[10] i_wb_addr[11] i_wb_addr[12] i_wb_addr[13] i_wb_addr[14]
+ i_wb_addr[15] i_wb_addr[16] i_wb_addr[17] i_wb_addr[18] i_wb_addr[19] i_wb_addr[1]
+ i_wb_addr[2] i_wb_addr[3] i_wb_addr[4] i_wb_addr[5] i_wb_addr[6] i_wb_addr[7] i_wb_addr[8]
+ i_wb_addr[9] i_wb_ctrl_stb i_wb_cyc i_wb_data[0] i_wb_data[10] i_wb_data[11] i_wb_data[12]
+ i_wb_data[13] i_wb_data[14] i_wb_data[15] i_wb_data[16] i_wb_data[17] i_wb_data[18]
+ i_wb_data[19] i_wb_data[1] i_wb_data[20] i_wb_data[21] i_wb_data[22] i_wb_data[23]
+ i_wb_data[24] i_wb_data[25] i_wb_data[26] i_wb_data[27] i_wb_data[28] i_wb_data[29]
+ i_wb_data[2] i_wb_data[30] i_wb_data[31] i_wb_data[3] i_wb_data[4] i_wb_data[5]
+ i_wb_data[6] i_wb_data[7] i_wb_data[8] i_wb_data[9] i_wb_data_stb i_wb_we o_interrupt
+ o_qspi_cs_n o_qspi_dat[0] o_qspi_dat[1] o_qspi_dat[2] o_qspi_dat[3] o_qspi_mod[0]
+ o_qspi_mod[1] o_qspi_sck o_wb_ack o_wb_data[0] o_wb_data[10] o_wb_data[11] o_wb_data[12]
+ o_wb_data[13] o_wb_data[14] o_wb_data[15] o_wb_data[16] o_wb_data[17] o_wb_data[18]
+ o_wb_data[19] o_wb_data[1] o_wb_data[20] o_wb_data[21] o_wb_data[22] o_wb_data[23]
+ o_wb_data[24] o_wb_data[25] o_wb_data[26] o_wb_data[27] o_wb_data[28] o_wb_data[29]
+ o_wb_data[2] o_wb_data[30] o_wb_data[31] o_wb_data[3] o_wb_data[4] o_wb_data[5]
+ o_wb_data[6] o_wb_data[7] o_wb_data[8] o_wb_data[9] o_wb_stall
X_2037_ _2734_/Q VGND VGND VPWR VPWR _2037_/Y sky130_fd_sc_hd__inv_2
XFILLER_54_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2106_ _2720_/Q _1770_/B _2121_/S VGND VGND VPWR VPWR _2720_/D sky130_fd_sc_hd__mux2_1
XFILLER_52_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1606_ _2650_/Q _1605_/X _1608_/S VGND VGND VPWR VPWR _2650_/D sky130_fd_sc_hd__mux2_1
XFILLER_8_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2655_ _2893_/CLK _2655_/D VGND VGND VPWR VPWR _2655_/Q sky130_fd_sc_hd__dfxtp_4
X_2724_ _2724_/CLK _2724_/D VGND VGND VPWR VPWR _2724_/Q sky130_fd_sc_hd__dfxtp_2
XFILLER_59_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1468_ _2729_/Q _1474_/B _2730_/Q VGND VGND VPWR VPWR _1469_/B sky130_fd_sc_hd__a21oi_1
X_1399_ _2619_/Q VGND VGND VPWR VPWR _1414_/A sky130_fd_sc_hd__inv_2
X_1537_ _1363_/B _1934_/B _1536_/X _2018_/C _1782_/A VGND VGND VPWR VPWR _1538_/D
+ sky130_fd_sc_hd__o221a_1
X_2586_ _2891_/Q _2585_/B _2594_/B VGND VGND VPWR VPWR _2587_/B sky130_fd_sc_hd__a21oi_1
XFILLER_27_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2440_ _2661_/Q _2658_/Q _2561_/S VGND VGND VPWR VPWR _2441_/C sky130_fd_sc_hd__mux2_1
X_2371_ _2825_/Q _1553_/X _2819_/D VGND VGND VPWR VPWR _2825_/D sky130_fd_sc_hd__mux2_1
XFILLER_56_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1322_ _2738_/Q _2813_/Q VGND VGND VPWR VPWR _1322_/X sky130_fd_sc_hd__and2b_1
XFILLER_5_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2638_ _2844_/CLK _2638_/D VGND VGND VPWR VPWR _2638_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_58_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2707_ _2748_/CLK _2707_/D VGND VGND VPWR VPWR _2707_/Q sky130_fd_sc_hd__dfxtp_1
X_2569_ _2687_/Q _2419_/A _2588_/B _2568_/X _2437_/X VGND VGND VPWR VPWR _2569_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_59_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1871_ _2676_/Q _1742_/B _1870_/X _1982_/S VGND VGND VPWR VPWR _2676_/D sky130_fd_sc_hd__a22o_1
X_1940_ _2685_/Q VGND VGND VPWR VPWR _1940_/Y sky130_fd_sc_hd__inv_2
XFILLER_14_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2423_ _2583_/B VGND VGND VPWR VPWR _2423_/X sky130_fd_sc_hd__buf_8
X_2285_ _2841_/Q _2304_/B _2295_/B _2698_/Q VGND VGND VPWR VPWR _2285_/X sky130_fd_sc_hd__a22o_1
XFILLER_37_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2354_ _2815_/Q _2341_/A _2353_/X _2346_/A VGND VGND VPWR VPWR _2815_/D sky130_fd_sc_hd__o22a_1
X_1305_ _2816_/Q _2778_/Q _2738_/Q VGND VGND VPWR VPWR _2001_/C sky130_fd_sc_hd__mux2_4
XFILLER_60_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2070_ _2087_/A _2070_/B VGND VGND VPWR VPWR _2707_/D sky130_fd_sc_hd__nor2_1
X_1923_ _2683_/Q _1923_/B VGND VGND VPWR VPWR _1923_/X sky130_fd_sc_hd__or2_1
X_1854_ _2674_/Q _1787_/A _1848_/X _1853_/X VGND VGND VPWR VPWR _1854_/X sky130_fd_sc_hd__a211o_1
X_1785_ _2665_/Q _1787_/A _1781_/X _1783_/X _1784_/X VGND VGND VPWR VPWR _1785_/X
+ sky130_fd_sc_hd__a221o_1
X_2406_ _2811_/Q _2894_/Q VGND VGND VPWR VPWR _2406_/Y sky130_fd_sc_hd__nor2_1
X_2268_ _2836_/Q _2304_/B _2295_/B _2693_/Q VGND VGND VPWR VPWR _2268_/X sky130_fd_sc_hd__a22o_1
X_2199_ _2009_/A _2014_/A _2158_/X _2027_/S VGND VGND VPWR VPWR _2210_/B sky130_fd_sc_hd__a211o_1
X_2337_ _2349_/A _2349_/B VGND VGND VPWR VPWR _2337_/Y sky130_fd_sc_hd__nand2_1
XFILLER_40_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1570_ _2632_/Q _1569_/X _1598_/S VGND VGND VPWR VPWR _2632_/D sky130_fd_sc_hd__mux2_1
XTAP_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_5 i_wb_data[0] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2122_ _2745_/Q _2823_/Q _2122_/S VGND VGND VPWR VPWR _2122_/X sky130_fd_sc_hd__mux2_1
X_2053_ _2272_/C _2053_/B VGND VGND VPWR VPWR _2701_/D sky130_fd_sc_hd__and2_1
XTAP_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1837_ _2758_/Q _2027_/S VGND VGND VPWR VPWR _1837_/X sky130_fd_sc_hd__and2_1
X_1906_ _2262_/B _1896_/X _1905_/X _2172_/A VGND VGND VPWR VPWR _1906_/X sky130_fd_sc_hd__a211o_1
X_2886_ _2893_/CLK _2886_/D VGND VGND VPWR VPWR _2886_/Q sky130_fd_sc_hd__dfxtp_1
X_1768_ _2662_/Q _1787_/A _1763_/X _1767_/X VGND VGND VPWR VPWR _1768_/X sky130_fd_sc_hd__a211o_1
X_1699_ _1988_/B _1698_/X _1695_/Y VGND VGND VPWR VPWR _1699_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_25_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_167 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput75 _2802_/Q VGND VGND VPWR VPWR o_wb_data[13] sky130_fd_sc_hd__clkbuf_1
Xoutput64 _1322_/X VGND VGND VPWR VPWR o_qspi_dat[1] sky130_fd_sc_hd__clkbuf_1
Xoutput86 _2806_/Q VGND VGND VPWR VPWR o_wb_data[23] sky130_fd_sc_hd__clkbuf_1
Xoutput97 _2793_/Q VGND VGND VPWR VPWR o_wb_data[4] sky130_fd_sc_hd__clkbuf_1
XFILLER_56_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1622_ _2262_/A _1622_/B _2172_/A _1688_/B VGND VGND VPWR VPWR _1623_/C sky130_fd_sc_hd__or4b_1
X_2740_ _2742_/CLK _2740_/D VGND VGND VPWR VPWR _2740_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_8_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2671_ _2876_/CLK _2671_/D VGND VGND VPWR VPWR _2671_/Q sky130_fd_sc_hd__dfxtp_1
X_1553_ _2623_/Q input4/X _2399_/S VGND VGND VPWR VPWR _1553_/X sky130_fd_sc_hd__mux2_1
XFILLER_39_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1484_ _1759_/B _1488_/B _1484_/C VGND VGND VPWR VPWR _1484_/X sky130_fd_sc_hd__and3_1
XTAP_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2036_ _2732_/Q _2036_/B VGND VGND VPWR VPWR _2036_/Y sky130_fd_sc_hd__nand2_1
X_2105_ _2719_/Q _1489_/A _2121_/S VGND VGND VPWR VPWR _2719_/D sky130_fd_sc_hd__mux2_1
XFILLER_22_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2869_ _2877_/CLK _2869_/D VGND VGND VPWR VPWR _2869_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_45_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2723_ _2724_/CLK _2723_/D VGND VGND VPWR VPWR _2723_/Q sky130_fd_sc_hd__dfxtp_1
X_1605_ _2649_/Q _2646_/Q _2818_/Q VGND VGND VPWR VPWR _1605_/X sky130_fd_sc_hd__mux2_1
X_1536_ _1782_/A _2737_/Q _2775_/Q VGND VGND VPWR VPWR _1536_/X sky130_fd_sc_hd__and3_1
X_2585_ _2891_/Q _2585_/B VGND VGND VPWR VPWR _2592_/B sky130_fd_sc_hd__or2_1
X_2654_ _2743_/CLK _2654_/D VGND VGND VPWR VPWR _2654_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_59_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1398_ _1914_/B _1731_/C _2193_/A VGND VGND VPWR VPWR _1398_/X sky130_fd_sc_hd__o21a_1
X_1467_ _2729_/Q _2730_/Q _1474_/B VGND VGND VPWR VPWR _1469_/A sky130_fd_sc_hd__and3_1
X_2019_ _2264_/A _1835_/A _1726_/A _1662_/A _1700_/B VGND VGND VPWR VPWR _2019_/X
+ sky130_fd_sc_hd__o41a_1
XFILLER_35_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2370_ _2824_/Q _1551_/X _2819_/D VGND VGND VPWR VPWR _2824_/D sky130_fd_sc_hd__mux2_1
X_1321_ _2738_/Q _2812_/Q VGND VGND VPWR VPWR _1321_/X sky130_fd_sc_hd__and2b_1
XFILLER_24_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2706_ _2857_/CLK _2706_/D VGND VGND VPWR VPWR _2706_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_59_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2637_ _2844_/CLK _2637_/D VGND VGND VPWR VPWR _2637_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_58_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1519_ _2209_/A _2209_/B _1518_/X VGND VGND VPWR VPWR _1519_/X sky130_fd_sc_hd__a21bo_1
X_2499_ _2673_/Q _2419_/A _2343_/X _2498_/X _2437_/X VGND VGND VPWR VPWR _2499_/X
+ sky130_fd_sc_hd__a221o_1
X_2568_ _2686_/Q _2683_/Q _2655_/Q VGND VGND VPWR VPWR _2568_/X sky130_fd_sc_hd__mux2_1
XFILLER_55_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1870_ _2676_/Q _1787_/A _1864_/X _1869_/X VGND VGND VPWR VPWR _1870_/X sky130_fd_sc_hd__a211o_1
X_2353_ _2606_/A _2888_/Q _2594_/B _2350_/Y _2688_/Q VGND VGND VPWR VPWR _2353_/X
+ sky130_fd_sc_hd__o32a_1
X_2422_ _2820_/Q _2334_/B _1311_/B _2410_/A VGND VGND VPWR VPWR _2583_/B sky130_fd_sc_hd__a31oi_4
X_2284_ _2283_/X _2783_/Q _2292_/S VGND VGND VPWR VPWR _2783_/D sky130_fd_sc_hd__mux2_1
XFILLER_56_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1999_ _1999_/A _1999_/B VGND VGND VPWR VPWR _1999_/Y sky130_fd_sc_hd__nor2_1
XFILLER_20_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_19_i_clk clkbuf_2_1__f_i_clk/X VGND VGND VPWR VPWR _2683_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_11_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1922_ _2188_/A _1900_/D _1921_/X _1899_/B _2732_/Q VGND VGND VPWR VPWR _1922_/X
+ sky130_fd_sc_hd__o32a_1
X_1853_ _2723_/Q _1899_/B _1852_/X VGND VGND VPWR VPWR _1853_/X sky130_fd_sc_hd__o21a_1
XFILLER_6_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1784_ _2193_/B _1784_/B _1784_/C VGND VGND VPWR VPWR _1784_/X sky130_fd_sc_hd__and3_1
X_2336_ _2888_/Q _2885_/Q _2571_/A VGND VGND VPWR VPWR _2336_/X sky130_fd_sc_hd__mux2_1
X_2405_ _2895_/Q _2891_/Q _2893_/Q _2892_/Q VGND VGND VPWR VPWR _2405_/X sky130_fd_sc_hd__or4_1
XFILLER_55_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2267_ _1406_/A _2018_/C _2609_/A VGND VGND VPWR VPWR _2295_/B sky130_fd_sc_hd__o21ai_4
X_2198_ _1630_/A _2223_/S _2197_/Y _2272_/C VGND VGND VPWR VPWR _2740_/D sky130_fd_sc_hd__o211a_1
XFILLER_25_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_6 i_wb_data[5] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2121_ _2735_/Q _1448_/A _2121_/S VGND VGND VPWR VPWR _2735_/D sky130_fd_sc_hd__mux2_1
X_2052_ _2051_/X _2701_/Q _2064_/S VGND VGND VPWR VPWR _2053_/B sky130_fd_sc_hd__mux2_1
XFILLER_34_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1905_ _1470_/A _2609_/A _1903_/X _1904_/X VGND VGND VPWR VPWR _1905_/X sky130_fd_sc_hd__o211a_1
XFILLER_22_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2885_ _2889_/CLK _2885_/D VGND VGND VPWR VPWR _2885_/Q sky130_fd_sc_hd__dfxtp_1
X_1836_ _1836_/A VGND VGND VPWR VPWR _1899_/B sky130_fd_sc_hd__buf_4
X_1767_ _2193_/B _1489_/A _1784_/C _1766_/X VGND VGND VPWR VPWR _1767_/X sky130_fd_sc_hd__a31o_1
X_1698_ _1698_/A _2262_/A _1698_/C _1698_/D VGND VGND VPWR VPWR _1698_/X sky130_fd_sc_hd__or4_1
X_2319_ _2810_/Q _2656_/Q _2321_/S VGND VGND VPWR VPWR _2810_/D sky130_fd_sc_hd__mux2_1
XFILLER_25_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput76 _2779_/Q VGND VGND VPWR VPWR o_wb_data[14] sky130_fd_sc_hd__clkbuf_1
Xoutput87 _2807_/Q VGND VGND VPWR VPWR o_wb_data[24] sky130_fd_sc_hd__clkbuf_1
Xoutput98 _2794_/Q VGND VGND VPWR VPWR o_wb_data[5] sky130_fd_sc_hd__clkbuf_1
XFILLER_0_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput65 _1323_/X VGND VGND VPWR VPWR o_qspi_dat[2] sky130_fd_sc_hd__clkbuf_1
XFILLER_31_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1552_ _2623_/Q _1551_/X _1598_/S VGND VGND VPWR VPWR _2623_/D sky130_fd_sc_hd__mux2_1
X_1621_ _1690_/A _1652_/B VGND VGND VPWR VPWR _1688_/B sky130_fd_sc_hd__or2_1
X_2670_ _2683_/CLK _2670_/D VGND VGND VPWR VPWR _2670_/Q sky130_fd_sc_hd__dfxtp_1
X_1483_ _2716_/Q _2717_/Q _2718_/Q VGND VGND VPWR VPWR _1484_/C sky130_fd_sc_hd__a21o_1
XTAP_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2104_ _2718_/Q _1759_/B _2121_/S VGND VGND VPWR VPWR _2718_/D sky130_fd_sc_hd__mux2_1
XFILLER_62_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2035_ _2695_/Q VGND VGND VPWR VPWR _2036_/B sky130_fd_sc_hd__inv_2
XFILLER_47_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2868_ _2877_/CLK _2868_/D VGND VGND VPWR VPWR _2868_/Q sky130_fd_sc_hd__dfxtp_1
X_2799_ _2836_/CLK _2799_/D VGND VGND VPWR VPWR _2799_/Q sky130_fd_sc_hd__dfxtp_1
X_1819_ _2670_/Q _2402_/S _1740_/A _1816_/X _1818_/X VGND VGND VPWR VPWR _1819_/X
+ sky130_fd_sc_hd__a311o_1
XFILLER_13_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2722_ _2724_/CLK _2722_/D VGND VGND VPWR VPWR _2722_/Q sky130_fd_sc_hd__dfxtp_2
X_1604_ _2649_/Q _1603_/X _1608_/S VGND VGND VPWR VPWR _2649_/D sky130_fd_sc_hd__mux2_1
X_1535_ _1676_/A _2186_/B VGND VGND VPWR VPWR _1535_/Y sky130_fd_sc_hd__nor2_1
X_2653_ _2653_/CLK _2653_/D VGND VGND VPWR VPWR _2653_/Q sky130_fd_sc_hd__dfxtp_4
X_2584_ _2582_/X _2426_/Y _2890_/Q _2600_/S VGND VGND VPWR VPWR _2890_/D sky130_fd_sc_hd__a2bb2o_1
X_1397_ _2691_/Q _1726_/A VGND VGND VPWR VPWR _1731_/C sky130_fd_sc_hd__nor2_1
X_1466_ _2728_/Q _1476_/C _1476_/D _1466_/D VGND VGND VPWR VPWR _1474_/B sky130_fd_sc_hd__and4_1
XFILLER_50_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2018_ _2205_/B _2018_/B _2018_/C _2018_/D VGND VGND VPWR VPWR _2018_/X sky130_fd_sc_hd__or4_1
XFILLER_2_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1320_ _2738_/Q _2399_/S VGND VGND VPWR VPWR _1320_/X sky130_fd_sc_hd__and2b_1
XFILLER_5_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2636_ _2838_/CLK _2636_/D VGND VGND VPWR VPWR _2636_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_32_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2705_ _2897_/CLK _2705_/D VGND VGND VPWR VPWR _2705_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_59_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1449_ _1476_/C _1476_/D _1466_/D VGND VGND VPWR VPWR _1450_/B sky130_fd_sc_hd__and3_1
X_1518_ _1988_/C _1628_/A _2609_/C VGND VGND VPWR VPWR _1518_/X sky130_fd_sc_hd__or3b_1
X_2498_ _2872_/Q _2869_/Q _2571_/A VGND VGND VPWR VPWR _2498_/X sky130_fd_sc_hd__mux2_1
X_2567_ _2606_/A _2883_/Q _2343_/X _2566_/X VGND VGND VPWR VPWR _2567_/X sky130_fd_sc_hd__o211a_1
XFILLER_55_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2283_ _2840_/Q _2304_/B _2295_/B _2697_/Q VGND VGND VPWR VPWR _2283_/X sky130_fd_sc_hd__a22o_1
X_2352_ _2814_/Q _2341_/A _2351_/X _2346_/A VGND VGND VPWR VPWR _2814_/D sky130_fd_sc_hd__o22a_1
X_2421_ _2820_/Q _2421_/B VGND VGND VPWR VPWR _2562_/A sky130_fd_sc_hd__nand2_8
XFILLER_64_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2619_ _2777_/CLK _2619_/D VGND VGND VPWR VPWR _2619_/Q sky130_fd_sc_hd__dfxtp_2
X_1998_ _2690_/Q _1706_/B _2193_/B VGND VGND VPWR VPWR _1999_/B sky130_fd_sc_hd__a21oi_1
XFILLER_43_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1852_ _2731_/Q _1763_/B _1851_/X _2012_/A VGND VGND VPWR VPWR _1852_/X sky130_fd_sc_hd__a211o_1
X_1921_ _1841_/A _1748_/B _2013_/B _2770_/Q VGND VGND VPWR VPWR _1921_/X sky130_fd_sc_hd__a22o_1
X_1783_ _2665_/Q _1782_/Y _2205_/B VGND VGND VPWR VPWR _1783_/X sky130_fd_sc_hd__a21o_1
X_2404_ _2606_/B VGND VGND VPWR VPWR _2404_/Y sky130_fd_sc_hd__inv_2
X_2335_ _2606_/B _2415_/B VGND VGND VPWR VPWR _2594_/B sky130_fd_sc_hd__nor2_8
X_2266_ _2714_/Q _2709_/Q _2715_/Q VGND VGND VPWR VPWR _2778_/D sky130_fd_sc_hd__or3b_1
XFILLER_52_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2197_ _2197_/A _2197_/B VGND VGND VPWR VPWR _2197_/Y sky130_fd_sc_hd__nand2_1
XFILLER_40_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_7 i_wb_data[5] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2120_ _2734_/Q _1505_/A _2121_/S VGND VGND VPWR VPWR _2734_/D sky130_fd_sc_hd__mux2_1
XTAP_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2051_ _2745_/Q _2823_/Q _2615_/B VGND VGND VPWR VPWR _2051_/X sky130_fd_sc_hd__mux2_1
X_1904_ _2090_/A _1655_/C _2609_/A VGND VGND VPWR VPWR _1904_/X sky130_fd_sc_hd__a21o_1
X_1835_ _1835_/A _2272_/A VGND VGND VPWR VPWR _1836_/A sky130_fd_sc_hd__or2_1
X_2884_ _2884_/CLK _2884_/D VGND VGND VPWR VPWR _2884_/Q sky130_fd_sc_hd__dfxtp_1
X_1697_ _2742_/Q _1838_/B _2000_/B VGND VGND VPWR VPWR _1698_/D sky130_fd_sc_hd__o21ai_1
X_1766_ _2749_/Q _2013_/B _2012_/A _1765_/Y VGND VGND VPWR VPWR _1766_/X sky130_fd_sc_hd__a211o_1
XFILLER_57_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2318_ _2809_/Q _2292_/S _2305_/X _2848_/Q VGND VGND VPWR VPWR _2809_/D sky130_fd_sc_hd__a22o_1
X_2249_ _2769_/Q input44/X _2255_/S VGND VGND VPWR VPWR _2769_/D sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_18_i_clk _2653_/CLK VGND VGND VPWR VPWR _2777_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_25_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput88 _2808_/Q VGND VGND VPWR VPWR o_wb_data[25] sky130_fd_sc_hd__clkbuf_1
Xoutput77 _2780_/Q VGND VGND VPWR VPWR o_wb_data[15] sky130_fd_sc_hd__clkbuf_1
Xoutput99 _2795_/Q VGND VGND VPWR VPWR o_wb_data[6] sky130_fd_sc_hd__clkbuf_1
Xoutput66 _1324_/X VGND VGND VPWR VPWR o_qspi_dat[3] sky130_fd_sc_hd__clkbuf_1
XFILLER_48_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1551_ _2622_/Q input3/X _2399_/S VGND VGND VPWR VPWR _1551_/X sky130_fd_sc_hd__mux2_1
X_1620_ _1620_/A VGND VGND VPWR VPWR _2172_/A sky130_fd_sc_hd__buf_4
X_1482_ _2716_/Q _2717_/Q _2718_/Q VGND VGND VPWR VPWR _1488_/B sky130_fd_sc_hd__nand3_1
XFILLER_54_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2103_ _2717_/Q _1963_/A _2121_/S VGND VGND VPWR VPWR _2717_/D sky130_fd_sc_hd__mux2_1
XTAP_158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2034_ _2029_/Y _2693_/Q _2030_/Y _2734_/Q _2033_/X VGND VGND VPWR VPWR _2034_/X
+ sky130_fd_sc_hd__o221a_1
X_2798_ _2829_/CLK _2798_/D VGND VGND VPWR VPWR _2798_/Q sky130_fd_sc_hd__dfxtp_1
X_1818_ _2670_/Q _1787_/A _1817_/X VGND VGND VPWR VPWR _1818_/X sky130_fd_sc_hd__a21o_1
XFILLER_22_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2867_ _2877_/CLK _2867_/D VGND VGND VPWR VPWR _2867_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_10_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1749_ _2659_/Q _1740_/A _1747_/X _1748_/Y VGND VGND VPWR VPWR _1751_/B sky130_fd_sc_hd__a22o_1
XFILLER_45_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2652_ _2837_/CLK _2652_/D VGND VGND VPWR VPWR _2652_/Q sky130_fd_sc_hd__dfxtp_1
X_2721_ _2876_/CLK _2721_/D VGND VGND VPWR VPWR _2721_/Q sky130_fd_sc_hd__dfxtp_2
X_1603_ _2648_/Q _2645_/Q _2818_/Q VGND VGND VPWR VPWR _1603_/X sky130_fd_sc_hd__mux2_1
X_1534_ _2688_/Q _2819_/Q _2653_/Q VGND VGND VPWR VPWR _2186_/B sky130_fd_sc_hd__and3b_1
X_1465_ _1465_/A _1465_/B _1465_/C _1465_/D VGND VGND VPWR VPWR _1492_/B sky130_fd_sc_hd__and4_1
X_2583_ _2583_/A _2583_/B VGND VGND VPWR VPWR _2600_/S sky130_fd_sc_hd__nand2_2
X_2017_ _2017_/A VGND VGND VPWR VPWR _2017_/Y sky130_fd_sc_hd__clkinv_2
X_1396_ _2264_/A _2016_/S VGND VGND VPWR VPWR _1727_/C sky130_fd_sc_hd__nor2_1
XFILLER_27_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2635_ _2838_/CLK _2635_/D VGND VGND VPWR VPWR _2635_/Q sky130_fd_sc_hd__dfxtp_1
X_2704_ _2775_/CLK _2704_/D VGND VGND VPWR VPWR _2704_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_59_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1517_ _1630_/A _2090_/A _1627_/A _1988_/A VGND VGND VPWR VPWR _2609_/C sky130_fd_sc_hd__or4b_2
X_1448_ _1448_/A _1448_/B VGND VGND VPWR VPWR _1492_/A sky130_fd_sc_hd__xnor2_1
XFILLER_4_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2566_ _2571_/A _2886_/Q VGND VGND VPWR VPWR _2566_/X sky130_fd_sc_hd__or2_1
X_2497_ _2562_/A _2594_/B _2497_/C VGND VGND VPWR VPWR _2497_/X sky130_fd_sc_hd__and3_1
X_1379_ _1988_/A _1433_/B VGND VGND VPWR VPWR _1685_/A sky130_fd_sc_hd__or2_2
XFILLER_23_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2420_ _2337_/Y _2411_/Y _2419_/Y _2365_/A _2857_/Q VGND VGND VPWR VPWR _2857_/D
+ sky130_fd_sc_hd__a32o_1
X_2282_ _2281_/X _2782_/Q _2292_/S VGND VGND VPWR VPWR _2782_/D sky130_fd_sc_hd__mux2_1
XFILLER_29_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2351_ _2606_/A _2887_/Q _2594_/B _2350_/Y _2687_/Q VGND VGND VPWR VPWR _2351_/X
+ sky130_fd_sc_hd__o32a_1
XFILLER_64_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1997_ _2689_/Q _2006_/S _1996_/Y _2172_/A VGND VGND VPWR VPWR _2689_/D sky130_fd_sc_hd__o22a_1
X_2618_ _2748_/CLK _2618_/D VGND VGND VPWR VPWR _2618_/Q sky130_fd_sc_hd__dfxtp_1
X_2549_ _2683_/Q _2419_/A _2343_/X _2548_/X _2437_/X VGND VGND VPWR VPWR _2549_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_18_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1851_ _2761_/Q _1943_/S _1849_/X _1850_/X _1841_/Y VGND VGND VPWR VPWR _1851_/X
+ sky130_fd_sc_hd__o221a_1
X_1920_ _2683_/Q _1782_/B _1914_/B VGND VGND VPWR VPWR _1920_/Y sky130_fd_sc_hd__o21ai_1
X_2403_ _2402_/X _2854_/Q _2403_/S VGND VGND VPWR VPWR _2854_/D sky130_fd_sc_hd__mux2_1
X_1782_ _1782_/A _1782_/B VGND VGND VPWR VPWR _1782_/Y sky130_fd_sc_hd__nor2_4
XFILLER_6_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2265_ _1706_/A _2247_/S _2264_/X VGND VGND VPWR VPWR _2777_/D sky130_fd_sc_hd__o21ai_1
XFILLER_37_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2196_ _1904_/X _2192_/Y _2195_/X _2016_/S VGND VGND VPWR VPWR _2197_/B sky130_fd_sc_hd__o2bb2a_1
X_2334_ _2855_/Q _2334_/B VGND VGND VPWR VPWR _2415_/B sky130_fd_sc_hd__nor2_4
XFILLER_52_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_8 i_wb_data[6] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2050_ _2272_/C _2050_/B VGND VGND VPWR VPWR _2700_/D sky130_fd_sc_hd__and2_1
XFILLER_15_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1903_ _2681_/Q _1740_/A _1901_/X _1902_/Y VGND VGND VPWR VPWR _1903_/X sky130_fd_sc_hd__a211o_1
X_1765_ _2402_/S _1765_/B VGND VGND VPWR VPWR _1765_/Y sky130_fd_sc_hd__nor2_8
X_2883_ _2883_/CLK _2883_/D VGND VGND VPWR VPWR _2883_/Q sky130_fd_sc_hd__dfxtp_1
X_1834_ _2672_/Q _1833_/X _1982_/S VGND VGND VPWR VPWR _2672_/D sky130_fd_sc_hd__mux2_1
X_1696_ _2090_/A _1696_/B VGND VGND VPWR VPWR _1698_/A sky130_fd_sc_hd__nor2_4
X_2317_ _2808_/Q _2292_/S _2305_/X _2847_/Q VGND VGND VPWR VPWR _2808_/D sky130_fd_sc_hd__a22o_1
XFILLER_57_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2248_ _2768_/Q input43/X _2255_/S VGND VGND VPWR VPWR _2768_/D sky130_fd_sc_hd__mux2_1
X_2179_ _2090_/A _2172_/B _2178_/X _2087_/A VGND VGND VPWR VPWR _2739_/D sky130_fd_sc_hd__a211o_1
XFILLER_15_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput78 _2781_/Q VGND VGND VPWR VPWR o_wb_data[16] sky130_fd_sc_hd__clkbuf_1
Xoutput89 _2809_/Q VGND VGND VPWR VPWR o_wb_data[26] sky130_fd_sc_hd__clkbuf_1
XFILLER_48_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput67 _1318_/X VGND VGND VPWR VPWR o_qspi_mod[0] sky130_fd_sc_hd__clkbuf_1
XFILLER_56_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1550_ _2622_/Q _1549_/X _1598_/S VGND VGND VPWR VPWR _2622_/D sky130_fd_sc_hd__mux2_1
XTAP_148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1481_ _1963_/A _2018_/C _1934_/B VGND VGND VPWR VPWR _1481_/X sky130_fd_sc_hd__and3_1
X_2033_ _2031_/Y _2733_/Q _2032_/Y _2694_/Q VGND VGND VPWR VPWR _2033_/X sky130_fd_sc_hd__o2bb2a_1
XFILLER_39_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2102_ _2716_/Q input5/X _2121_/S VGND VGND VPWR VPWR _2716_/D sky130_fd_sc_hd__mux2_1
XTAP_159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2797_ _2836_/CLK _2797_/D VGND VGND VPWR VPWR _2797_/Q sky130_fd_sc_hd__dfxtp_1
X_1817_ _2193_/B input7/X _1784_/C _1765_/Y _1489_/A VGND VGND VPWR VPWR _1817_/X
+ sky130_fd_sc_hd__a32o_1
X_1748_ _1841_/A _1748_/B VGND VGND VPWR VPWR _1748_/Y sky130_fd_sc_hd__nand2_1
X_2866_ _2877_/CLK _2866_/D VGND VGND VPWR VPWR _2866_/Q sky130_fd_sc_hd__dfxtp_1
X_1679_ _2209_/A _1678_/X _2142_/C _2188_/A VGND VGND VPWR VPWR _1680_/D sky130_fd_sc_hd__a211o_1
XFILLER_53_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1602_ _2648_/Q _1601_/X _1608_/S VGND VGND VPWR VPWR _2648_/D sky130_fd_sc_hd__mux2_1
X_2651_ _2854_/CLK _2651_/D VGND VGND VPWR VPWR _2651_/Q sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_17_i_clk _2653_/CLK VGND VGND VPWR VPWR _2730_/CLK sky130_fd_sc_hd__clkbuf_16
X_2582_ _2582_/A _2585_/B _2582_/C VGND VGND VPWR VPWR _2582_/X sky130_fd_sc_hd__and3_1
XFILLER_8_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2720_ _2876_/CLK _2720_/D VGND VGND VPWR VPWR _2720_/Q sky130_fd_sc_hd__dfxtp_2
X_1395_ _1395_/A VGND VGND VPWR VPWR _2016_/S sky130_fd_sc_hd__clkbuf_4
X_1533_ _2272_/A _2272_/B VGND VGND VPWR VPWR _2260_/A sky130_fd_sc_hd__nand2_2
X_1464_ _1784_/B _1458_/X _1460_/Y _1461_/X _1463_/Y VGND VGND VPWR VPWR _1465_/D
+ sky130_fd_sc_hd__o221a_1
X_2016_ input47/X _2772_/Q _2016_/S VGND VGND VPWR VPWR _2017_/A sky130_fd_sc_hd__mux2_1
XFILLER_27_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2849_ _2853_/CLK _2849_/D VGND VGND VPWR VPWR _2849_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_12_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2634_ _2836_/CLK _2634_/D VGND VGND VPWR VPWR _2634_/Q sky130_fd_sc_hd__dfxtp_1
X_1516_ _1713_/B _2027_/S VGND VGND VPWR VPWR _1628_/A sky130_fd_sc_hd__or2_1
X_2703_ _2896_/CLK _2703_/D VGND VGND VPWR VPWR _2703_/Q sky130_fd_sc_hd__dfxtp_1
X_2565_ _2886_/Q _2423_/X _2562_/X _2564_/X VGND VGND VPWR VPWR _2886_/D sky130_fd_sc_hd__o22a_1
XFILLER_55_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1447_ _2735_/Q _1505_/B VGND VGND VPWR VPWR _1448_/B sky130_fd_sc_hd__xnor2_1
X_1378_ _1630_/A _2090_/A _1627_/A VGND VGND VPWR VPWR _1433_/B sky130_fd_sc_hd__or3_1
XFILLER_4_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2496_ _2672_/Q _2669_/Q _2561_/S VGND VGND VPWR VPWR _2497_/C sky130_fd_sc_hd__mux2_1
XFILLER_23_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2281_ _2839_/Q _2304_/B _2295_/B _2696_/Q VGND VGND VPWR VPWR _2281_/X sky130_fd_sc_hd__a22o_1
X_2350_ _2561_/S _2415_/C VGND VGND VPWR VPWR _2350_/Y sky130_fd_sc_hd__nand2_1
XFILLER_64_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1996_ _1996_/A _2006_/S VGND VGND VPWR VPWR _1996_/Y sky130_fd_sc_hd__nand2_1
X_2617_ _2897_/Q _2610_/X _2616_/X VGND VGND VPWR VPWR _2897_/D sky130_fd_sc_hd__o21ba_1
X_2548_ _2882_/Q _2879_/Q _2811_/Q VGND VGND VPWR VPWR _2548_/X sky130_fd_sc_hd__mux2_1
XFILLER_43_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2479_ _2669_/Q _2419_/A _2343_/X _2478_/X _2437_/X VGND VGND VPWR VPWR _2479_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_18_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1850_ _2701_/Q _2123_/B _2614_/B _2745_/Q _2013_/B VGND VGND VPWR VPWR _1850_/X
+ sky130_fd_sc_hd__a221o_1
X_1781_ _2722_/Q _1645_/Y _1748_/Y _1780_/X _1698_/A VGND VGND VPWR VPWR _1781_/X
+ sky130_fd_sc_hd__a311o_1
X_2402_ _2691_/Q _2401_/X _2402_/S VGND VGND VPWR VPWR _2402_/X sky130_fd_sc_hd__mux2_1
X_2333_ _2346_/A _2361_/B VGND VGND VPWR VPWR _2341_/A sky130_fd_sc_hd__nor2_2
X_2264_ _2264_/A _2609_/A _2193_/A VGND VGND VPWR VPWR _2264_/X sky130_fd_sc_hd__or3b_1
X_2195_ _1664_/X _1962_/Y _2194_/X _2264_/A VGND VGND VPWR VPWR _2195_/X sky130_fd_sc_hd__o22a_1
XFILLER_25_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1979_ _2736_/Q _1748_/B _1932_/X VGND VGND VPWR VPWR _1980_/D sky130_fd_sc_hd__o21a_1
XFILLER_45_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_9 i_wb_data[7] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1902_ _2205_/A _2205_/B _2402_/S VGND VGND VPWR VPWR _1902_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_15_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1764_ _2264_/A _2193_/B VGND VGND VPWR VPWR _1765_/B sky130_fd_sc_hd__nand2_2
X_1833_ _2672_/Q _2402_/S _1740_/A _1830_/X _1832_/X VGND VGND VPWR VPWR _1833_/X
+ sky130_fd_sc_hd__a311o_1
X_2882_ _2884_/CLK _2882_/D VGND VGND VPWR VPWR _2882_/Q sky130_fd_sc_hd__dfxtp_1
X_2316_ _2807_/Q _2292_/S _2305_/X _2846_/Q VGND VGND VPWR VPWR _2807_/D sky130_fd_sc_hd__a22o_1
X_1695_ _1695_/A _1695_/B VGND VGND VPWR VPWR _1695_/Y sky130_fd_sc_hd__nor2_1
X_2247_ _2767_/Q input42/X _2247_/S VGND VGND VPWR VPWR _2767_/D sky130_fd_sc_hd__mux2_1
X_2178_ _2262_/B _1765_/Y _2171_/Y _2197_/A _2177_/X VGND VGND VPWR VPWR _2178_/X
+ sky130_fd_sc_hd__o311a_1
XFILLER_25_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput79 _2782_/Q VGND VGND VPWR VPWR o_wb_data[17] sky130_fd_sc_hd__clkbuf_1
XFILLER_56_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput68 _1320_/X VGND VGND VPWR VPWR o_qspi_mod[1] sky130_fd_sc_hd__clkbuf_1
XFILLER_0_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1480_ _2018_/C _1934_/B _1963_/A VGND VGND VPWR VPWR _1480_/Y sky130_fd_sc_hd__a21oi_1
XTAP_149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2032_ _2731_/Q VGND VGND VPWR VPWR _2032_/Y sky130_fd_sc_hd__inv_2
X_2101_ _2101_/A VGND VGND VPWR VPWR _2121_/S sky130_fd_sc_hd__buf_6
XFILLER_30_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2865_ _2884_/CLK _2865_/D VGND VGND VPWR VPWR _2865_/Q sky130_fd_sc_hd__dfxtp_1
X_2796_ _2829_/CLK _2796_/D VGND VGND VPWR VPWR _2796_/Q sky130_fd_sc_hd__dfxtp_1
X_1678_ _2653_/Q _2619_/Q _2209_/B _1678_/D VGND VGND VPWR VPWR _1678_/X sky130_fd_sc_hd__or4_1
X_1816_ _2727_/Q _1763_/B _1815_/X VGND VGND VPWR VPWR _1816_/X sky130_fd_sc_hd__a21o_1
X_1747_ _2746_/Q _2013_/B _1645_/Y _2716_/Q VGND VGND VPWR VPWR _1747_/X sky130_fd_sc_hd__a22o_1
XFILLER_53_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_0_i_clk i_clk VGND VGND VPWR VPWR clkbuf_0_i_clk/X sky130_fd_sc_hd__clkbuf_16
XFILLER_8_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1601_ _2647_/Q _2644_/Q _2818_/Q VGND VGND VPWR VPWR _1601_/X sky130_fd_sc_hd__mux2_1
X_2650_ _2854_/CLK _2650_/D VGND VGND VPWR VPWR _2650_/Q sky130_fd_sc_hd__dfxtp_1
X_1532_ _1708_/A _1617_/B VGND VGND VPWR VPWR _2272_/B sky130_fd_sc_hd__nand2_2
X_2581_ _2890_/Q _2581_/B VGND VGND VPWR VPWR _2582_/C sky130_fd_sc_hd__nand2_1
X_1394_ _1835_/A _1708_/B VGND VGND VPWR VPWR _1395_/A sky130_fd_sc_hd__or2_1
XFILLER_27_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1463_ _1770_/B _1463_/B VGND VGND VPWR VPWR _1463_/Y sky130_fd_sc_hd__xnor2_1
X_2015_ _2011_/X _2691_/Q _2015_/S VGND VGND VPWR VPWR _2691_/D sky130_fd_sc_hd__mux2_1
XFILLER_35_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2848_ _2850_/CLK _2848_/D VGND VGND VPWR VPWR _2848_/Q sky130_fd_sc_hd__dfxtp_1
X_2779_ _2844_/CLK _2779_/D VGND VGND VPWR VPWR _2779_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_2_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2702_ _2896_/CLK _2702_/D VGND VGND VPWR VPWR _2702_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_59_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2633_ _2836_/CLK _2633_/D VGND VGND VPWR VPWR _2633_/Q sky130_fd_sc_hd__dfxtp_1
X_1515_ _1838_/A _1736_/B VGND VGND VPWR VPWR _2027_/S sky130_fd_sc_hd__nor2_4
XFILLER_4_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2495_ _2872_/Q _2423_/X _2492_/X _2494_/X VGND VGND VPWR VPWR _2872_/D sky130_fd_sc_hd__o22a_1
X_2564_ _2686_/Q _2419_/A _2343_/X _2563_/X _2437_/X VGND VGND VPWR VPWR _2564_/X
+ sky130_fd_sc_hd__a221o_1
X_1377_ _1630_/A _2000_/A VGND VGND VPWR VPWR _1676_/A sky130_fd_sc_hd__or2_2
X_1446_ _2732_/Q _2733_/Q _2734_/Q _1493_/C VGND VGND VPWR VPWR _1505_/B sky130_fd_sc_hd__nand4_2
XFILLER_58_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_16_i_clk _2653_/CLK VGND VGND VPWR VPWR _2854_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_46_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2280_ _2279_/X _2781_/Q _2292_/S VGND VGND VPWR VPWR _2781_/D sky130_fd_sc_hd__mux2_1
XFILLER_49_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1995_ _1904_/X _1993_/X _1994_/X _1916_/X VGND VGND VPWR VPWR _1996_/A sky130_fd_sc_hd__a22o_1
X_2616_ _2614_/Y _2610_/X _2615_/Y _2087_/A VGND VGND VPWR VPWR _2616_/X sky130_fd_sc_hd__a31o_1
XFILLER_20_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1429_ _1429_/A VGND VGND VPWR VPWR _2402_/S sky130_fd_sc_hd__buf_6
X_2478_ _2868_/Q _2865_/Q _2571_/A VGND VGND VPWR VPWR _2478_/X sky130_fd_sc_hd__mux2_1
X_2547_ _2562_/A _2594_/B _2547_/C VGND VGND VPWR VPWR _2547_/X sky130_fd_sc_hd__and3_1
XFILLER_34_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1780_ _2752_/Q _2013_/B _2123_/B _2744_/Q VGND VGND VPWR VPWR _1780_/X sky130_fd_sc_hd__a22o_1
X_2401_ _2822_/Q _1684_/B _2205_/C _2304_/B _2853_/Q VGND VGND VPWR VPWR _2401_/X
+ sky130_fd_sc_hd__a32o_1
XFILLER_6_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2332_ _2357_/A _2349_/B VGND VGND VPWR VPWR _2361_/B sky130_fd_sc_hd__and2_1
X_2263_ _2776_/Q _2172_/A _2256_/X _2262_/X VGND VGND VPWR VPWR _2776_/D sky130_fd_sc_hd__a22o_1
XFILLER_37_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2194_ _2193_/A _1914_/B _2174_/X _2193_/X VGND VGND VPWR VPWR _2194_/X sky130_fd_sc_hd__a31o_1
XFILLER_52_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1978_ _2775_/Q _1943_/S _1930_/Y VGND VGND VPWR VPWR _1980_/C sky130_fd_sc_hd__o21a_1
XFILLER_29_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1901_ _2730_/Q _1899_/B _1900_/X VGND VGND VPWR VPWR _1901_/X sky130_fd_sc_hd__o21a_1
X_2881_ _2884_/CLK _2881_/D VGND VGND VPWR VPWR _2881_/Q sky130_fd_sc_hd__dfxtp_1
X_1832_ _2672_/Q _1787_/A _1831_/X VGND VGND VPWR VPWR _1832_/X sky130_fd_sc_hd__a21o_1
X_1694_ _2090_/A _2211_/A VGND VGND VPWR VPWR _1695_/A sky130_fd_sc_hd__and2_1
X_1763_ _2719_/Q _1763_/B VGND VGND VPWR VPWR _1763_/X sky130_fd_sc_hd__and2_1
X_2315_ _2806_/Q _2292_/S _2305_/X _2845_/Q VGND VGND VPWR VPWR _2806_/D sky130_fd_sc_hd__a22o_1
X_2246_ _2766_/Q input41/X _2247_/S VGND VGND VPWR VPWR _2766_/D sky130_fd_sc_hd__mux2_1
X_2177_ _2173_/Y _2176_/X _2016_/S VGND VGND VPWR VPWR _2177_/X sky130_fd_sc_hd__a21o_1
XFILLER_25_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput69 _1317_/X VGND VGND VPWR VPWR o_qspi_sck sky130_fd_sc_hd__clkbuf_1
XFILLER_48_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2100_ _2129_/C _2130_/A _2100_/C VGND VGND VPWR VPWR _2101_/A sky130_fd_sc_hd__and3_1
XTAP_139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2031_ _2696_/Q VGND VGND VPWR VPWR _2031_/Y sky130_fd_sc_hd__inv_2
XFILLER_22_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2795_ _2829_/CLK _2795_/D VGND VGND VPWR VPWR _2795_/Q sky130_fd_sc_hd__dfxtp_1
X_1815_ _2749_/Q _2123_/B _1814_/X VGND VGND VPWR VPWR _1815_/X sky130_fd_sc_hd__a21o_1
XFILLER_22_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2864_ _2884_/CLK _2864_/D VGND VGND VPWR VPWR _2864_/Q sky130_fd_sc_hd__dfxtp_1
X_1677_ _1386_/B _1675_/Y _2099_/C VGND VGND VPWR VPWR _1680_/C sky130_fd_sc_hd__a21oi_2
X_1746_ _1746_/A VGND VGND VPWR VPWR _1982_/S sky130_fd_sc_hd__buf_8
X_2229_ _2749_/Q input54/X _2247_/S VGND VGND VPWR VPWR _2749_/D sky130_fd_sc_hd__mux2_1
XFILLER_53_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1600_ _2647_/Q _1599_/X _1608_/S VGND VGND VPWR VPWR _2647_/D sky130_fd_sc_hd__mux2_1
X_1531_ _1630_/A _2090_/A VGND VGND VPWR VPWR _1708_/A sky130_fd_sc_hd__nor2_4
X_2580_ _2890_/Q _2581_/B VGND VGND VPWR VPWR _2585_/B sky130_fd_sc_hd__or2_1
X_1462_ _2720_/Q _1476_/C VGND VGND VPWR VPWR _1463_/B sky130_fd_sc_hd__xor2_1
X_1393_ _1726_/A _1928_/A _2262_/A VGND VGND VPWR VPWR _2270_/A sky130_fd_sc_hd__o21ai_1
X_2014_ _2014_/A _2047_/A _1983_/X VGND VGND VPWR VPWR _2015_/S sky130_fd_sc_hd__or3b_1
XFILLER_35_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2847_ _2850_/CLK _2847_/D VGND VGND VPWR VPWR _2847_/Q sky130_fd_sc_hd__dfxtp_1
X_2778_ _2816_/CLK _2778_/D VGND VGND VPWR VPWR _2778_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_58_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1729_ _2691_/Q _2262_/B _1655_/C _1728_/X VGND VGND VPWR VPWR _1729_/X sky130_fd_sc_hd__a31o_1
XTAP_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2632_ _2836_/CLK _2632_/D VGND VGND VPWR VPWR _2632_/Q sky130_fd_sc_hd__dfxtp_1
X_2701_ _2775_/CLK _2701_/D VGND VGND VPWR VPWR _2701_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_32_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1445_ _1445_/A VGND VGND VPWR VPWR _1493_/C sky130_fd_sc_hd__clkbuf_2
X_1514_ _2127_/A _2009_/B VGND VGND VPWR VPWR _1713_/B sky130_fd_sc_hd__or2_1
XFILLER_4_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2494_ _2672_/Q _2419_/A _2343_/X _2493_/X _2437_/X VGND VGND VPWR VPWR _2494_/X
+ sky130_fd_sc_hd__a221o_1
X_2563_ _2885_/Q _2882_/Q _2811_/Q VGND VGND VPWR VPWR _2563_/X sky130_fd_sc_hd__mux2_1
XFILLER_55_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1376_ _2090_/A _1617_/B VGND VGND VPWR VPWR _2000_/A sky130_fd_sc_hd__nand2_2
XFILLER_63_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1994_ _2588_/A _1914_/Y _1782_/B _1765_/B _2736_/Q VGND VGND VPWR VPWR _1994_/X
+ sky130_fd_sc_hd__o32a_1
XFILLER_20_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2615_ _2828_/Q _2615_/B VGND VGND VPWR VPWR _2615_/Y sky130_fd_sc_hd__nand2_1
X_1428_ _1708_/B _1652_/B VGND VGND VPWR VPWR _1429_/A sky130_fd_sc_hd__or2_1
X_2477_ _2562_/A _2594_/B _2477_/C VGND VGND VPWR VPWR _2477_/X sky130_fd_sc_hd__and3_1
X_2546_ _2682_/Q _2679_/Q _2561_/S VGND VGND VPWR VPWR _2547_/C sky130_fd_sc_hd__mux2_1
XFILLER_51_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1359_ _1835_/A _1639_/A VGND VGND VPWR VPWR _1988_/B sky130_fd_sc_hd__nor2_2
XFILLER_50_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2400_ _2853_/Q _2399_/X _2400_/S VGND VGND VPWR VPWR _2853_/D sky130_fd_sc_hd__mux2_1
XFILLER_10_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2262_ _2262_/A _2262_/B _2262_/C _2262_/D VGND VGND VPWR VPWR _2262_/X sky130_fd_sc_hd__or4_1
X_2331_ _2857_/Q _2330_/Y _2365_/B VGND VGND VPWR VPWR _2349_/B sky130_fd_sc_hd__a21bo_1
XFILLER_37_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2193_ _2193_/A _2193_/B _2193_/C VGND VGND VPWR VPWR _2193_/X sky130_fd_sc_hd__and3_1
XFILLER_1_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1977_ _2688_/Q _1782_/Y _1934_/Y _2205_/B VGND VGND VPWR VPWR _1977_/X sky130_fd_sc_hd__a211o_1
Xclkbuf_leaf_15_i_clk _2653_/CLK VGND VGND VPWR VPWR _2850_/CLK sky130_fd_sc_hd__clkbuf_16
X_2529_ _2679_/Q _2419_/A _2343_/X _2528_/X _2437_/X VGND VGND VPWR VPWR _2529_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1900_ _1932_/A _2188_/A _1900_/C _1900_/D VGND VGND VPWR VPWR _1900_/X sky130_fd_sc_hd__or4_1
X_2880_ _2884_/CLK _2880_/D VGND VGND VPWR VPWR _2880_/Q sky130_fd_sc_hd__dfxtp_1
X_1831_ _2193_/B input9/X _1784_/C _1765_/Y _1461_/A VGND VGND VPWR VPWR _1831_/X
+ sky130_fd_sc_hd__a32o_1
X_1762_ _2661_/Q _1742_/B _1761_/X _1982_/S VGND VGND VPWR VPWR _2661_/D sky130_fd_sc_hd__a22o_1
X_1693_ _2561_/S _1687_/X _1692_/X VGND VGND VPWR VPWR _2655_/D sky130_fd_sc_hd__o21ba_1
XFILLER_57_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2314_ _2805_/Q _2292_/S _2305_/X _2844_/Q VGND VGND VPWR VPWR _2805_/D sky130_fd_sc_hd__a22o_1
X_2245_ _2765_/Q input40/X _2247_/S VGND VGND VPWR VPWR _2765_/D sky130_fd_sc_hd__mux2_1
X_2176_ _2193_/A _2193_/B _1963_/X _2175_/Y _2264_/A VGND VGND VPWR VPWR _2176_/X
+ sky130_fd_sc_hd__a311o_1
XFILLER_21_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2030_ _2697_/Q VGND VGND VPWR VPWR _2030_/Y sky130_fd_sc_hd__inv_2
XPHY_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2794_ _2828_/CLK _2794_/D VGND VGND VPWR VPWR _2794_/Q sky130_fd_sc_hd__dfxtp_1
X_1745_ _1709_/X _2610_/A _1723_/Y _1738_/X VGND VGND VPWR VPWR _1746_/A sky130_fd_sc_hd__o211a_1
XFILLER_30_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1814_ _2757_/Q _2013_/B _2012_/A _2719_/Q VGND VGND VPWR VPWR _1814_/X sky130_fd_sc_hd__a22o_1
X_2863_ _2884_/CLK _2863_/D VGND VGND VPWR VPWR _2863_/Q sky130_fd_sc_hd__dfxtp_1
X_1676_ _1676_/A _2186_/B VGND VGND VPWR VPWR _2099_/C sky130_fd_sc_hd__or2_1
X_2159_ _2209_/A _2209_/B _2158_/X VGND VGND VPWR VPWR _2159_/X sky130_fd_sc_hd__a21bo_1
X_2228_ _2748_/Q input53/X _2247_/S VGND VGND VPWR VPWR _2748_/D sky130_fd_sc_hd__mux2_1
XFILLER_53_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1530_ _2018_/B _1984_/A _1529_/X _1676_/A VGND VGND VPWR VPWR _1530_/X sky130_fd_sc_hd__o211a_1
X_1392_ _1392_/A VGND VGND VPWR VPWR _1928_/A sky130_fd_sc_hd__clkbuf_2
X_1461_ _1461_/A _1461_/B _1461_/C VGND VGND VPWR VPWR _1461_/X sky130_fd_sc_hd__and3_1
X_2013_ _2122_/S _2013_/B _2188_/A _2013_/D VGND VGND VPWR VPWR _2047_/A sky130_fd_sc_hd__or4_1
XFILLER_35_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2846_ _2853_/CLK _2846_/D VGND VGND VPWR VPWR _2846_/Q sky130_fd_sc_hd__dfxtp_1
X_2777_ _2777_/CLK _2777_/D VGND VGND VPWR VPWR _2777_/Q sky130_fd_sc_hd__dfxtp_1
X_1728_ input5/X _1725_/X _1726_/Y _1727_/X VGND VGND VPWR VPWR _1728_/X sky130_fd_sc_hd__o211a_1
XTAP_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1659_ _1897_/B _1782_/B _1538_/D VGND VGND VPWR VPWR _1659_/X sky130_fd_sc_hd__a21o_1
XFILLER_37_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2631_ _2836_/CLK _2631_/D VGND VGND VPWR VPWR _2631_/Q sky130_fd_sc_hd__dfxtp_1
X_2700_ _2897_/CLK _2700_/D VGND VGND VPWR VPWR _2700_/Q sky130_fd_sc_hd__dfxtp_1
X_2562_ _2562_/A _2594_/B _2562_/C VGND VGND VPWR VPWR _2562_/X sky130_fd_sc_hd__and3_1
X_1375_ _1988_/A _1838_/A VGND VGND VPWR VPWR _1617_/B sky130_fd_sc_hd__nor2_2
X_1444_ _1476_/C _1476_/D _1466_/D _1444_/D VGND VGND VPWR VPWR _1445_/A sky130_fd_sc_hd__and4_1
X_1513_ _1838_/A _1838_/B VGND VGND VPWR VPWR _2009_/B sky130_fd_sc_hd__nor2_4
X_2493_ _2871_/Q _2868_/Q _2571_/A VGND VGND VPWR VPWR _2493_/X sky130_fd_sc_hd__mux2_1
X_2829_ _2829_/CLK _2829_/D VGND VGND VPWR VPWR _2829_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_2_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1993_ _2000_/A _1989_/X _1990_/Y _1992_/X VGND VGND VPWR VPWR _1993_/X sky130_fd_sc_hd__a31o_1
X_2614_ _2750_/Q _2614_/B VGND VGND VPWR VPWR _2614_/Y sky130_fd_sc_hd__nand2_1
X_2545_ _2882_/Q _2423_/X _2542_/X _2544_/X VGND VGND VPWR VPWR _2882_/D sky130_fd_sc_hd__o22a_1
XFILLER_55_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1427_ _2262_/B _1422_/X _1426_/X _2150_/A _1419_/Y VGND VGND VPWR VPWR _1427_/Y
+ sky130_fd_sc_hd__a311oi_1
X_1358_ _1782_/A _2737_/Q VGND VGND VPWR VPWR _2001_/D sky130_fd_sc_hd__nor2_2
XFILLER_28_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2476_ _2668_/Q _2665_/Q _2561_/S VGND VGND VPWR VPWR _2477_/C sky130_fd_sc_hd__mux2_1
XFILLER_55_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2261_ _2776_/Q _2261_/B _2261_/C VGND VGND VPWR VPWR _2262_/D sky130_fd_sc_hd__and3_1
X_2330_ _2856_/Q _2855_/Q VGND VGND VPWR VPWR _2330_/Y sky130_fd_sc_hd__nor2_1
X_2192_ _2185_/Y _2188_/X _2191_/X VGND VGND VPWR VPWR _2192_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_52_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1976_ _1962_/Y _1975_/Y _1928_/Y VGND VGND VPWR VPWR _1976_/X sky130_fd_sc_hd__o21ba_1
X_2528_ _2878_/Q _2875_/Q _2811_/Q VGND VGND VPWR VPWR _2528_/X sky130_fd_sc_hd__mux2_1
XFILLER_45_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2459_ _2665_/Q _2419_/A _2588_/B _2458_/X _2437_/X VGND VGND VPWR VPWR _2459_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_61_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1830_ _2729_/Q _1763_/B _1829_/X VGND VGND VPWR VPWR _1830_/X sky130_fd_sc_hd__a21o_1
X_1761_ _2718_/Q _1763_/B _1760_/X VGND VGND VPWR VPWR _1761_/X sky130_fd_sc_hd__a21o_1
X_2313_ _2804_/Q _2292_/S _2305_/X _2843_/Q VGND VGND VPWR VPWR _2804_/D sky130_fd_sc_hd__a22o_1
X_1692_ _2000_/B _1687_/X _1691_/Y _2087_/A VGND VGND VPWR VPWR _1692_/X sky130_fd_sc_hd__a31o_1
X_2244_ _2764_/Q input39/X _2247_/S VGND VGND VPWR VPWR _2764_/D sky130_fd_sc_hd__mux2_1
X_2175_ _1963_/X _2174_/X _1662_/A VGND VGND VPWR VPWR _2175_/Y sky130_fd_sc_hd__a21oi_1
X_1959_ _1698_/A _2018_/D _1953_/X _1958_/X VGND VGND VPWR VPWR _1959_/X sky130_fd_sc_hd__a31o_1
XFILLER_56_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_14_i_clk _2653_/CLK VGND VGND VPWR VPWR _2853_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_46_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2793_ _2828_/CLK _2793_/D VGND VGND VPWR VPWR _2793_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_30_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1813_ _2669_/Q _1812_/X _1982_/S VGND VGND VPWR VPWR _2669_/D sky130_fd_sc_hd__mux2_1
X_2862_ _2889_/CLK _2862_/D VGND VGND VPWR VPWR _2862_/Q sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_29_i_clk clkbuf_leaf_3_i_clk/A VGND VGND VPWR VPWR _2748_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_7_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1744_ _2745_/Q _2013_/B _1742_/X _2658_/Q VGND VGND VPWR VPWR _2658_/D sky130_fd_sc_hd__a22o_1
X_1675_ _2776_/Q _2261_/B VGND VGND VPWR VPWR _1675_/Y sky130_fd_sc_hd__nand2_1
XFILLER_38_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2089_ _2272_/C _2089_/B VGND VGND VPWR VPWR _2714_/D sky130_fd_sc_hd__nand2_1
X_2158_ _1988_/A _1613_/B _1713_/B VGND VGND VPWR VPWR _2158_/X sky130_fd_sc_hd__a21o_1
X_2227_ _2747_/Q input52/X _2247_/S VGND VGND VPWR VPWR _2747_/D sky130_fd_sc_hd__mux2_1
XFILLER_53_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1391_ _2264_/A _1914_/B _2193_/A VGND VGND VPWR VPWR _1392_/A sky130_fd_sc_hd__or3b_1
XFILLER_4_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1460_ _1461_/B _1461_/C _1461_/A VGND VGND VPWR VPWR _1460_/Y sky130_fd_sc_hd__a21oi_1
X_2012_ _2012_/A _2172_/A _2142_/C _2012_/D VGND VGND VPWR VPWR _2013_/D sky130_fd_sc_hd__or4_1
X_2845_ _2850_/CLK _2845_/D VGND VGND VPWR VPWR _2845_/Q sky130_fd_sc_hd__dfxtp_1
X_2776_ _2838_/CLK _2776_/D VGND VGND VPWR VPWR _2776_/Q sky130_fd_sc_hd__dfxtp_1
X_1727_ _2193_/A _1914_/B _1727_/C VGND VGND VPWR VPWR _1727_/X sky130_fd_sc_hd__and3_1
X_1658_ _2691_/Q _2692_/Q VGND VGND VPWR VPWR _1782_/B sky130_fd_sc_hd__nor2_4
XFILLER_12_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1589_ _2641_/Q _2638_/Q _2399_/S VGND VGND VPWR VPWR _1589_/X sky130_fd_sc_hd__mux2_1
XTAP_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2630_ _2836_/CLK _2630_/D VGND VGND VPWR VPWR _2630_/Q sky130_fd_sc_hd__dfxtp_1
X_1512_ _1512_/A _1656_/A _1656_/B VGND VGND VPWR VPWR _2209_/B sky130_fd_sc_hd__and3_2
XFILLER_40_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2492_ _2562_/A _2594_/B _2492_/C VGND VGND VPWR VPWR _2492_/X sky130_fd_sc_hd__and3_1
X_2561_ _2685_/Q _2682_/Q _2561_/S VGND VGND VPWR VPWR _2562_/C sky130_fd_sc_hd__mux2_1
X_1443_ _2728_/Q _2729_/Q _2730_/Q _2731_/Q VGND VGND VPWR VPWR _1444_/D sky130_fd_sc_hd__and4_1
X_1374_ _2741_/Q _2742_/Q VGND VGND VPWR VPWR _1838_/A sky130_fd_sc_hd__nand2b_4
XFILLER_4_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2828_ _2828_/CLK _2828_/D VGND VGND VPWR VPWR _2828_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_23_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2759_ _2896_/CLK _2759_/D VGND VGND VPWR VPWR _2759_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_64_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1992_ _2205_/A _2205_/D _1923_/B _2588_/A _1698_/A VGND VGND VPWR VPWR _1992_/X
+ sky130_fd_sc_hd__o221a_1
XFILLER_9_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2613_ _2896_/Q _2610_/X _2612_/X _2272_/C VGND VGND VPWR VPWR _2896_/D sky130_fd_sc_hd__o211a_1
X_2475_ _2868_/Q _2423_/X _2472_/X _2474_/X VGND VGND VPWR VPWR _2868_/D sky130_fd_sc_hd__o22a_1
X_2544_ _2682_/Q _2419_/A _2588_/B _2543_/X _2437_/X VGND VGND VPWR VPWR _2544_/X
+ sky130_fd_sc_hd__a221o_1
X_1357_ _1988_/A _1835_/A _1627_/A VGND VGND VPWR VPWR _1357_/X sky130_fd_sc_hd__or3_1
X_1426_ _2692_/Q _1731_/C _1662_/B _1662_/A VGND VGND VPWR VPWR _1426_/X sky130_fd_sc_hd__a211o_1
XFILLER_55_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2260_ _2260_/A _2260_/B _2260_/C _2259_/X VGND VGND VPWR VPWR _2261_/C sky130_fd_sc_hd__or4b_1
XFILLER_37_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2191_ _2691_/Q _2189_/Y _1897_/B _2205_/B _2190_/X VGND VGND VPWR VPWR _2191_/X
+ sky130_fd_sc_hd__a311o_1
XFILLER_60_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1975_ _2688_/Q _1706_/B _2193_/B VGND VGND VPWR VPWR _1975_/Y sky130_fd_sc_hd__a21oi_1
X_1409_ _2272_/A _2609_/A VGND VGND VPWR VPWR _1410_/D sky130_fd_sc_hd__nand2_1
X_2527_ _2562_/A _2594_/B _2527_/C VGND VGND VPWR VPWR _2527_/X sky130_fd_sc_hd__and3_1
X_2458_ _2664_/Q _2661_/Q _2561_/S VGND VGND VPWR VPWR _2458_/X sky130_fd_sc_hd__mux2_1
X_2389_ _2843_/Q _1589_/X _2819_/D VGND VGND VPWR VPWR _2843_/D sky130_fd_sc_hd__mux2_1
XFILLER_45_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1691_ _2090_/A _2821_/Q _1841_/B _2262_/A VGND VGND VPWR VPWR _1691_/Y sky130_fd_sc_hd__a31oi_1
X_1760_ _2748_/Q _2013_/B _1787_/A _2661_/Q _1759_/X VGND VGND VPWR VPWR _1760_/X
+ sky130_fd_sc_hd__a221o_1
X_2312_ _2803_/Q _2292_/S _2305_/X _2842_/Q VGND VGND VPWR VPWR _2803_/D sky130_fd_sc_hd__a22o_1
XFILLER_32_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2174_ _1726_/A _1928_/B _1725_/X VGND VGND VPWR VPWR _2174_/X sky130_fd_sc_hd__a21o_1
X_2243_ _2763_/Q input37/X _2247_/S VGND VGND VPWR VPWR _2763_/D sky130_fd_sc_hd__mux2_1
XFILLER_21_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1958_ _2735_/Q _1899_/B _1954_/X _1956_/Y _1957_/X VGND VGND VPWR VPWR _1958_/X
+ sky130_fd_sc_hd__o2111a_1
XFILLER_31_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1889_ _2766_/Q _1943_/S _1899_/B _2728_/Q VGND VGND VPWR VPWR _1890_/C sky130_fd_sc_hd__o22a_1
XFILLER_56_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2861_ _2889_/CLK _2861_/D VGND VGND VPWR VPWR _2861_/Q sky130_fd_sc_hd__dfxtp_1
X_2792_ _2828_/CLK _2792_/D VGND VGND VPWR VPWR _2792_/Q sky130_fd_sc_hd__dfxtp_1
X_1674_ _2135_/B _2172_/A _1683_/D VGND VGND VPWR VPWR _1680_/B sky130_fd_sc_hd__or3_1
X_1812_ _2669_/Q _2402_/S _1740_/A _1809_/X _1811_/X VGND VGND VPWR VPWR _1812_/X
+ sky130_fd_sc_hd__a311o_1
XFILLER_7_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1743_ _2744_/Q _2013_/B _1742_/X _2657_/Q VGND VGND VPWR VPWR _2657_/D sky130_fd_sc_hd__a22o_1
X_2226_ _2746_/Q input49/X _2247_/S VGND VGND VPWR VPWR _2746_/D sky130_fd_sc_hd__mux2_1
XFILLER_53_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2157_ _2188_/A VGND VGND VPWR VPWR _2157_/Y sky130_fd_sc_hd__inv_2
XFILLER_38_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2088_ _2714_/Q _2088_/B VGND VGND VPWR VPWR _2089_/B sky130_fd_sc_hd__xnor2_1
XFILLER_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1390_ _1390_/A VGND VGND VPWR VPWR _1726_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_50_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2011_ _2127_/A _2011_/B VGND VGND VPWR VPWR _2011_/X sky130_fd_sc_hd__or2_1
XFILLER_35_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2844_ _2844_/CLK _2844_/D VGND VGND VPWR VPWR _2844_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_50_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1588_ _2641_/Q _1587_/X _1598_/S VGND VGND VPWR VPWR _2641_/D sky130_fd_sc_hd__mux2_1
X_2775_ _2775_/CLK _2775_/D VGND VGND VPWR VPWR _2775_/Q sky130_fd_sc_hd__dfxtp_2
X_1726_ _1726_/A _1928_/B VGND VGND VPWR VPWR _1726_/Y sky130_fd_sc_hd__nand2_1
X_1657_ _1641_/Y _1651_/X _2260_/B _1656_/X VGND VGND VPWR VPWR _1657_/X sky130_fd_sc_hd__a211o_1
XFILLER_58_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2209_ _2209_/A _2209_/B VGND VGND VPWR VPWR _2210_/A sky130_fd_sc_hd__nand2_1
XFILLER_41_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_13_i_clk _2653_/CLK VGND VGND VPWR VPWR _2844_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_49_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_28_i_clk clkbuf_leaf_3_i_clk/A VGND VGND VPWR VPWR _2857_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_40_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1511_ _1511_/A _1511_/B _1511_/C _1511_/D VGND VGND VPWR VPWR _1656_/B sky130_fd_sc_hd__and4_1
X_1442_ _2724_/Q _2725_/Q _2726_/Q _2727_/Q VGND VGND VPWR VPWR _1466_/D sky130_fd_sc_hd__and4_1
X_2560_ _2885_/Q _2423_/X _2557_/X _2559_/X VGND VGND VPWR VPWR _2885_/D sky130_fd_sc_hd__o22a_1
X_2491_ _2671_/Q _2668_/Q _2561_/S VGND VGND VPWR VPWR _2492_/C sky130_fd_sc_hd__mux2_1
X_1373_ _2819_/Q _1406_/A VGND VGND VPWR VPWR _2046_/A sky130_fd_sc_hd__nor2_1
XFILLER_63_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2827_ _2828_/CLK _2827_/D VGND VGND VPWR VPWR _2827_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_31_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2758_ _2896_/CLK _2758_/D VGND VGND VPWR VPWR _2758_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_58_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1709_ _2260_/A _2304_/B _1708_/X _2270_/B VGND VGND VPWR VPWR _1709_/X sky130_fd_sc_hd__or4bb_4
X_2689_ _2883_/CLK _2689_/D VGND VGND VPWR VPWR _2689_/Q sky130_fd_sc_hd__dfxtp_2
XTAP_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2612_ _2612_/A _2612_/B _2610_/X VGND VGND VPWR VPWR _2612_/X sky130_fd_sc_hd__or3b_1
X_1991_ _2689_/Q VGND VGND VPWR VPWR _2588_/A sky130_fd_sc_hd__inv_2
X_1425_ _2193_/A _1914_/B VGND VGND VPWR VPWR _1662_/A sky130_fd_sc_hd__nand2_1
X_2474_ _2668_/Q _2419_/A _2588_/B _2473_/X _2437_/X VGND VGND VPWR VPWR _2474_/X
+ sky130_fd_sc_hd__a221o_1
X_2543_ _2681_/Q _2678_/Q _2655_/Q VGND VGND VPWR VPWR _2543_/X sky130_fd_sc_hd__mux2_1
XFILLER_55_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1356_ _2742_/Q _2741_/Q VGND VGND VPWR VPWR _1627_/A sky130_fd_sc_hd__nand2_2
XFILLER_51_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2190_ _2737_/Q _2717_/Q _2018_/C _1934_/B _1782_/A VGND VGND VPWR VPWR _2190_/X
+ sky130_fd_sc_hd__o2111a_1
XFILLER_1_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1974_ _2687_/Q _1973_/X _1982_/S VGND VGND VPWR VPWR _2687_/D sky130_fd_sc_hd__mux2_1
Xclkbuf_2_2__f_i_clk clkbuf_0_i_clk/X VGND VGND VPWR VPWR clkbuf_leaf_9_i_clk/A sky130_fd_sc_hd__clkbuf_16
XFILLER_20_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2388_ _2842_/Q _1587_/X _2819_/D VGND VGND VPWR VPWR _2842_/D sky130_fd_sc_hd__mux2_1
X_1408_ _1630_/A _1700_/B VGND VGND VPWR VPWR _2609_/A sky130_fd_sc_hd__nand2_8
X_2457_ _2606_/A _2861_/Q _2343_/X _2456_/X VGND VGND VPWR VPWR _2457_/X sky130_fd_sc_hd__o211a_1
X_2526_ _2678_/Q _2675_/Q _2561_/S VGND VGND VPWR VPWR _2527_/C sky130_fd_sc_hd__mux2_1
X_1339_ _1914_/B _2692_/Q _1784_/C VGND VGND VPWR VPWR _2150_/A sky130_fd_sc_hd__and3_1
XFILLER_24_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1690_ _1690_/A _1838_/B VGND VGND VPWR VPWR _1841_/B sky130_fd_sc_hd__nor2_4
X_2311_ _2802_/Q _2292_/S _2305_/X _2835_/Q VGND VGND VPWR VPWR _2802_/D sky130_fd_sc_hd__a22o_1
X_2242_ _2762_/Q input36/X _2247_/S VGND VGND VPWR VPWR _2762_/D sky130_fd_sc_hd__mux2_1
XFILLER_25_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2173_ _1664_/X _1999_/A _2264_/A VGND VGND VPWR VPWR _2173_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_33_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1957_ _2090_/A _2180_/B _1640_/B _1696_/B _2000_/A VGND VGND VPWR VPWR _1957_/X
+ sky130_fd_sc_hd__o2111a_1
XFILLER_21_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1888_ _2897_/Q _2123_/B _2614_/B _2750_/Q _1908_/C VGND VGND VPWR VPWR _1890_/B
+ sky130_fd_sc_hd__a221o_1
X_2509_ _2675_/Q _2419_/A _2343_/X _2508_/X _2437_/X VGND VGND VPWR VPWR _2509_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_56_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2791_ _2828_/CLK _2791_/D VGND VGND VPWR VPWR _2791_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_30_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1811_ _2669_/Q _1787_/A _1810_/X VGND VGND VPWR VPWR _1811_/X sky130_fd_sc_hd__a21o_1
XPHY_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2860_ _2889_/CLK _2860_/D VGND VGND VPWR VPWR _2860_/Q sky130_fd_sc_hd__dfxtp_1
X_1673_ _2821_/Q _2188_/A _2162_/B VGND VGND VPWR VPWR _1683_/D sky130_fd_sc_hd__a21o_1
XFILLER_7_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1742_ _1787_/A _1742_/B VGND VGND VPWR VPWR _1742_/X sky130_fd_sc_hd__or2_1
XFILLER_38_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2225_ _2745_/Q input38/X _2247_/S VGND VGND VPWR VPWR _2745_/D sky130_fd_sc_hd__mux2_1
XFILLER_53_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2156_ _2260_/A VGND VGND VPWR VPWR _2156_/Y sky130_fd_sc_hd__inv_2
X_2087_ _2087_/A _2087_/B _2088_/B VGND VGND VPWR VPWR _2713_/D sky130_fd_sc_hd__or3_1
XFILLER_44_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2010_ _2009_/B _2027_/S _2007_/X _2148_/B _2691_/Q VGND VGND VPWR VPWR _2011_/B
+ sky130_fd_sc_hd__o32a_1
X_2843_ _2844_/CLK _2843_/D VGND VGND VPWR VPWR _2843_/Q sky130_fd_sc_hd__dfxtp_1
X_2774_ _2775_/CLK _2774_/D VGND VGND VPWR VPWR _2774_/Q sky130_fd_sc_hd__dfxtp_1
X_1725_ _2691_/Q _1731_/A VGND VGND VPWR VPWR _1725_/X sky130_fd_sc_hd__or2b_1
X_1587_ _2640_/Q _2637_/Q _2399_/S VGND VGND VPWR VPWR _1587_/X sky130_fd_sc_hd__mux2_1
XTAP_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1656_ _1656_/A _1656_/B _1656_/C VGND VGND VPWR VPWR _1656_/X sky130_fd_sc_hd__and3_1
Xclkbuf_leaf_9_i_clk clkbuf_leaf_9_i_clk/A VGND VGND VPWR VPWR _2836_/CLK sky130_fd_sc_hd__clkbuf_16
XTAP_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2208_ _2197_/A _2207_/X _2741_/Q _2223_/S VGND VGND VPWR VPWR _2741_/D sky130_fd_sc_hd__o2bb2a_1
X_2139_ _2821_/Q _2655_/Q VGND VGND VPWR VPWR _2139_/X sky130_fd_sc_hd__and2b_1
XFILLER_32_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1510_ _1503_/Y _1505_/B _1505_/X _1506_/Y _1509_/X VGND VGND VPWR VPWR _1511_/D
+ sky130_fd_sc_hd__o221a_1
X_1441_ _2720_/Q _2721_/Q _2722_/Q _2723_/Q VGND VGND VPWR VPWR _1476_/D sky130_fd_sc_hd__and4_2
XFILLER_4_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2490_ _2871_/Q _2423_/X _2487_/X _2489_/X VGND VGND VPWR VPWR _2871_/D sky130_fd_sc_hd__o22a_1
XFILLER_63_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1372_ _2821_/Q _1369_/X _1406_/A VGND VGND VPWR VPWR _1372_/X sky130_fd_sc_hd__o21a_1
X_2826_ _2828_/CLK _2826_/D VGND VGND VPWR VPWR _2826_/Q sky130_fd_sc_hd__dfxtp_1
X_1708_ _1708_/A _1708_/B VGND VGND VPWR VPWR _1708_/X sky130_fd_sc_hd__or2_1
X_2757_ _2896_/CLK _2757_/D VGND VGND VPWR VPWR _2757_/Q sky130_fd_sc_hd__dfxtp_1
X_2688_ _2883_/CLK _2688_/D VGND VGND VPWR VPWR _2688_/Q sky130_fd_sc_hd__dfxtp_2
XFILLER_48_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1639_ _1639_/A _1838_/B VGND VGND VPWR VPWR _1640_/B sky130_fd_sc_hd__or2_2
XTAP_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1990_ _2188_/A _1990_/B VGND VGND VPWR VPWR _1990_/Y sky130_fd_sc_hd__nor2_1
X_2611_ _2827_/Q _2615_/B VGND VGND VPWR VPWR _2612_/B sky130_fd_sc_hd__and2_1
XFILLER_9_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2542_ _2606_/A _2878_/Q _2343_/X _2541_/X VGND VGND VPWR VPWR _2542_/X sky130_fd_sc_hd__o211a_1
X_1355_ _1708_/B _1652_/B VGND VGND VPWR VPWR _2262_/A sky130_fd_sc_hd__nor2_4
X_1424_ _1731_/A _1726_/A _1928_/B VGND VGND VPWR VPWR _1662_/B sky130_fd_sc_hd__o21ai_1
X_2473_ _2667_/Q _2664_/Q _2561_/S VGND VGND VPWR VPWR _2473_/X sky130_fd_sc_hd__mux2_1
XFILLER_36_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_12_i_clk _2653_/CLK VGND VGND VPWR VPWR _2838_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_34_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2809_ _2850_/CLK _2809_/D VGND VGND VPWR VPWR _2809_/Q sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_27_i_clk clkbuf_leaf_3_i_clk/A VGND VGND VPWR VPWR _2895_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_61_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1973_ _2687_/Q _1787_/A _1999_/A _1784_/C _1972_/X VGND VGND VPWR VPWR _1973_/X
+ sky130_fd_sc_hd__a221o_1
X_2525_ _2878_/Q _2423_/X _2522_/X _2524_/X VGND VGND VPWR VPWR _2878_/D sky130_fd_sc_hd__o22a_1
X_2387_ _2841_/Q _1585_/X _2819_/D VGND VGND VPWR VPWR _2841_/D sky130_fd_sc_hd__mux2_1
X_1338_ _1338_/A VGND VGND VPWR VPWR _1784_/C sky130_fd_sc_hd__buf_6
X_1407_ _1708_/B VGND VGND VPWR VPWR _1700_/B sky130_fd_sc_hd__clkinv_4
XFILLER_28_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2456_ _2571_/A _2864_/Q VGND VGND VPWR VPWR _2456_/X sky130_fd_sc_hd__or2_1
XFILLER_51_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2310_ _2801_/Q _2292_/S _2305_/X _2834_/Q VGND VGND VPWR VPWR _2801_/D sky130_fd_sc_hd__a22o_1
X_2172_ _2172_/A _2172_/B VGND VGND VPWR VPWR _2197_/A sky130_fd_sc_hd__nor2_1
X_2241_ _2761_/Q input35/X _2247_/S VGND VGND VPWR VPWR _2761_/D sky130_fd_sc_hd__mux2_1
XFILLER_18_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1887_ _2678_/Q _1742_/B _1886_/X _1982_/S VGND VGND VPWR VPWR _2678_/D sky130_fd_sc_hd__a22o_1
XFILLER_33_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1956_ _1955_/Y _1748_/B _1841_/A VGND VGND VPWR VPWR _1956_/Y sky130_fd_sc_hd__o21ai_1
X_2508_ _2874_/Q _2871_/Q _2571_/A VGND VGND VPWR VPWR _2508_/X sky130_fd_sc_hd__mux2_1
XFILLER_56_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2439_ _2861_/Q _2423_/X _2434_/X _2438_/X VGND VGND VPWR VPWR _2861_/D sky130_fd_sc_hd__o22a_1
XFILLER_16_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2790_ _2828_/CLK _2790_/D VGND VGND VPWR VPWR _2790_/Q sky130_fd_sc_hd__dfxtp_1
X_1741_ _1741_/A VGND VGND VPWR VPWR _1742_/B sky130_fd_sc_hd__clkbuf_4
X_1810_ _2193_/B input6/X _1784_/C _1765_/Y _1759_/B VGND VGND VPWR VPWR _1810_/X
+ sky130_fd_sc_hd__a32o_1
XFILLER_15_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1672_ _2654_/Q VGND VGND VPWR VPWR _1672_/Y sky130_fd_sc_hd__inv_2
XFILLER_38_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2155_ _2223_/S VGND VGND VPWR VPWR _2172_/B sky130_fd_sc_hd__inv_2
X_2224_ _2744_/Q input27/X _2247_/S VGND VGND VPWR VPWR _2744_/D sky130_fd_sc_hd__mux2_1
XFILLER_53_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2086_ _2713_/Q _2086_/B VGND VGND VPWR VPWR _2088_/B sky130_fd_sc_hd__nor2_1
X_1939_ _2684_/Q _1926_/B _1938_/X VGND VGND VPWR VPWR _2684_/D sky130_fd_sc_hd__a21o_1
XFILLER_44_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2842_ _2844_/CLK _2842_/D VGND VGND VPWR VPWR _2842_/Q sky130_fd_sc_hd__dfxtp_1
X_2773_ _2824_/CLK _2773_/D VGND VGND VPWR VPWR _2773_/Q sky130_fd_sc_hd__dfxtp_1
X_1724_ _2193_/A _2264_/A VGND VGND VPWR VPWR _2256_/B sky130_fd_sc_hd__or2_1
X_1586_ _2640_/Q _1585_/X _1598_/S VGND VGND VPWR VPWR _2640_/D sky130_fd_sc_hd__mux2_1
XTAP_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1655_ _2776_/Q _2186_/A _1655_/C VGND VGND VPWR VPWR _1656_/C sky130_fd_sc_hd__and3_1
XTAP_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2207_ _2609_/A _1899_/B _2204_/X _2205_/X _2206_/X VGND VGND VPWR VPWR _2207_/X
+ sky130_fd_sc_hd__a41o_1
XFILLER_26_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2069_ _2707_/Q _2072_/C VGND VGND VPWR VPWR _2070_/B sky130_fd_sc_hd__xor2_1
X_2138_ _2821_/Q _2653_/Q VGND VGND VPWR VPWR _2349_/A sky130_fd_sc_hd__and2b_1
XFILLER_64_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1371_ _1988_/A _1612_/A VGND VGND VPWR VPWR _1406_/A sky130_fd_sc_hd__or2_2
X_1440_ _2776_/Q _2264_/A _1914_/B _1461_/B VGND VGND VPWR VPWR _1512_/A sky130_fd_sc_hd__and4_1
XFILLER_4_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2825_ _2828_/CLK _2825_/D VGND VGND VPWR VPWR _2825_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_23_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1638_ _2652_/Q _1637_/B _1637_/Y _2819_/Q VGND VGND VPWR VPWR _2652_/D sky130_fd_sc_hd__a22o_1
X_2756_ _2896_/CLK _2756_/D VGND VGND VPWR VPWR _2756_/Q sky130_fd_sc_hd__dfxtp_1
X_1707_ _2205_/B _1923_/B VGND VGND VPWR VPWR _1740_/A sky130_fd_sc_hd__nor2_4
X_2687_ _2883_/CLK _2687_/D VGND VGND VPWR VPWR _2687_/Q sky130_fd_sc_hd__dfxtp_1
X_1569_ _2631_/Q _2628_/Q _2399_/S VGND VGND VPWR VPWR _1569_/X sky130_fd_sc_hd__mux2_1
XFILLER_58_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_8_i_clk clkbuf_leaf_9_i_clk/A VGND VGND VPWR VPWR _2829_/CLK sky130_fd_sc_hd__clkbuf_16
X_2610_ _2610_/A _2610_/B _2610_/C _2610_/D VGND VGND VPWR VPWR _2610_/X sky130_fd_sc_hd__and4_1
X_2472_ _2606_/A _2864_/Q _2343_/X _2471_/X VGND VGND VPWR VPWR _2472_/X sky130_fd_sc_hd__o211a_1
X_2541_ _2571_/A _2881_/Q VGND VGND VPWR VPWR _2541_/X sky130_fd_sc_hd__or2_1
XFILLER_9_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1354_ _1630_/A _2090_/A VGND VGND VPWR VPWR _1652_/B sky130_fd_sc_hd__nand2_2
XFILLER_48_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1423_ _1963_/A input5/X VGND VGND VPWR VPWR _1928_/B sky130_fd_sc_hd__nand2_1
XFILLER_63_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2808_ _2850_/CLK _2808_/D VGND VGND VPWR VPWR _2808_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_11_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2739_ _2742_/CLK _2739_/D VGND VGND VPWR VPWR _2739_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_27_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1972_ _1969_/X _1990_/B _1971_/X VGND VGND VPWR VPWR _1972_/X sky130_fd_sc_hd__o21a_1
X_2455_ _2864_/Q _2423_/X _2452_/X _2454_/X VGND VGND VPWR VPWR _2864_/D sky130_fd_sc_hd__o22a_1
XFILLER_5_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2524_ _2678_/Q _2419_/A _2588_/B _2523_/X _2437_/X VGND VGND VPWR VPWR _2524_/X
+ sky130_fd_sc_hd__a221o_1
X_2386_ _2840_/Q _1583_/X _2819_/D VGND VGND VPWR VPWR _2840_/D sky130_fd_sc_hd__mux2_1
X_1406_ _1406_/A _1685_/A VGND VGND VPWR VPWR _1410_/C sky130_fd_sc_hd__nand2_1
X_1337_ _2264_/A _2262_/B VGND VGND VPWR VPWR _1338_/A sky130_fd_sc_hd__and2_1
XFILLER_28_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2171_ _2090_/A _1410_/D _2156_/Y _2167_/X _2170_/X VGND VGND VPWR VPWR _2171_/Y
+ sky130_fd_sc_hd__a221oi_1
X_2240_ _2760_/Q input34/X _2247_/S VGND VGND VPWR VPWR _2760_/D sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_26_i_clk clkbuf_leaf_3_i_clk/A VGND VGND VPWR VPWR _2893_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_33_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1886_ _2678_/Q _1787_/A _1880_/X _1885_/X VGND VGND VPWR VPWR _1886_/X sky130_fd_sc_hd__a211o_1
X_1955_ _2736_/Q VGND VGND VPWR VPWR _1955_/Y sky130_fd_sc_hd__inv_2
X_2438_ _2661_/Q _2419_/A _2343_/X _2435_/X _2437_/X VGND VGND VPWR VPWR _2438_/X
+ sky130_fd_sc_hd__a221o_1
X_2507_ _2562_/A _2594_/B _2507_/C VGND VGND VPWR VPWR _2507_/X sky130_fd_sc_hd__and3_1
XFILLER_56_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2369_ _2823_/Q _1549_/X _2819_/D VGND VGND VPWR VPWR _2823_/D sky130_fd_sc_hd__mux2_1
XFILLER_24_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1671_ _1661_/X _1666_/X _2083_/B _2653_/Q VGND VGND VPWR VPWR _2653_/D sky130_fd_sc_hd__o22a_1
X_1740_ _1740_/A _1926_/B VGND VGND VPWR VPWR _1741_/A sky130_fd_sc_hd__or2_1
XFILLER_30_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2154_ _2018_/B _2135_/X _2152_/X _2153_/X VGND VGND VPWR VPWR _2223_/S sky130_fd_sc_hd__a211oi_4
X_2223_ _1988_/A _2222_/X _2223_/S VGND VGND VPWR VPWR _2743_/D sky130_fd_sc_hd__mux2_1
X_2085_ _2713_/Q _2086_/B VGND VGND VPWR VPWR _2087_/B sky130_fd_sc_hd__and2_1
XFILLER_61_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1869_ _2725_/Q _1899_/B _1868_/X VGND VGND VPWR VPWR _1869_/X sky130_fd_sc_hd__o21a_1
X_1938_ _2016_/S _1655_/C _1929_/X _1937_/X _1982_/S VGND VGND VPWR VPWR _1938_/X
+ sky130_fd_sc_hd__o311a_1
XFILLER_29_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2841_ _2853_/CLK _2841_/D VGND VGND VPWR VPWR _2841_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_35_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2772_ _2829_/CLK _2772_/D VGND VGND VPWR VPWR _2772_/Q sky130_fd_sc_hd__dfxtp_1
X_1654_ _2264_/A _1730_/A VGND VGND VPWR VPWR _1655_/C sky130_fd_sc_hd__and2_1
X_1723_ _2738_/D _1723_/B VGND VGND VPWR VPWR _1723_/Y sky130_fd_sc_hd__nor2_1
X_1585_ _2639_/Q _2636_/Q _2399_/S VGND VGND VPWR VPWR _1585_/X sky130_fd_sc_hd__mux2_1
XTAP_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2206_ _2691_/Q _1765_/B _1916_/X VGND VGND VPWR VPWR _2206_/X sky130_fd_sc_hd__o21a_1
XFILLER_41_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2137_ _2262_/A _1678_/D _2136_/X _2188_/C VGND VGND VPWR VPWR _2142_/B sky130_fd_sc_hd__a22o_1
XFILLER_26_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2068_ _2072_/C _2067_/Y _2087_/A VGND VGND VPWR VPWR _2706_/D sky130_fd_sc_hd__a21oi_1
XFILLER_5_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1370_ _1627_/A _1630_/A _2090_/A VGND VGND VPWR VPWR _1612_/A sky130_fd_sc_hd__or3b_2
XFILLER_48_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2824_ _2824_/CLK _2824_/D VGND VGND VPWR VPWR _2824_/Q sky130_fd_sc_hd__dfxtp_1
X_1637_ _2262_/B _1637_/B VGND VGND VPWR VPWR _1637_/Y sky130_fd_sc_hd__nor2_1
X_2686_ _2730_/CLK _2686_/D VGND VGND VPWR VPWR _2686_/Q sky130_fd_sc_hd__dfxtp_2
X_1706_ _1706_/A _1706_/B VGND VGND VPWR VPWR _1923_/B sky130_fd_sc_hd__nand2_2
X_2755_ _2896_/CLK _2755_/D VGND VGND VPWR VPWR _2755_/Q sky130_fd_sc_hd__dfxtp_1
X_1568_ _2631_/Q _1567_/X _1598_/S VGND VGND VPWR VPWR _2631_/D sky130_fd_sc_hd__mux2_1
XFILLER_39_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1499_ _2726_/Q VGND VGND VPWR VPWR _1499_/Y sky130_fd_sc_hd__inv_2
XTAP_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1422_ _1398_/X _1421_/Y _2264_/A VGND VGND VPWR VPWR _1422_/X sky130_fd_sc_hd__o21ba_1
X_2471_ _2571_/A _2867_/Q VGND VGND VPWR VPWR _2471_/X sky130_fd_sc_hd__or2_1
X_2540_ _2881_/Q _2423_/X _2537_/X _2539_/X VGND VGND VPWR VPWR _2881_/D sky130_fd_sc_hd__o22a_1
X_1353_ _1363_/B _2018_/C _2018_/B _1538_/B _2205_/B VGND VGND VPWR VPWR _1353_/Y
+ sky130_fd_sc_hd__a2111oi_1
XFILLER_63_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2807_ _2850_/CLK _2807_/D VGND VGND VPWR VPWR _2807_/Q sky130_fd_sc_hd__dfxtp_1
X_2738_ _2893_/CLK _2738_/D VGND VGND VPWR VPWR _2738_/Q sky130_fd_sc_hd__dfxtp_2
XFILLER_59_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2669_ _2683_/CLK _2669_/D VGND VGND VPWR VPWR _2669_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_39_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1971_ _2687_/Q _1782_/Y _2205_/B VGND VGND VPWR VPWR _1971_/X sky130_fd_sc_hd__a21o_1
X_2385_ _2839_/Q _1581_/X _2819_/D VGND VGND VPWR VPWR _2839_/D sky130_fd_sc_hd__mux2_1
X_1405_ _1988_/A _1835_/A _1627_/A VGND VGND VPWR VPWR _2122_/S sky130_fd_sc_hd__nor3_4
X_2454_ _2664_/Q _2419_/A _2343_/X _2453_/X _2437_/X VGND VGND VPWR VPWR _2454_/X
+ sky130_fd_sc_hd__a221o_1
X_2523_ _2677_/Q _2674_/Q _2655_/Q VGND VGND VPWR VPWR _2523_/X sky130_fd_sc_hd__mux2_1
Xinput1 i_qspi_dat[0] VGND VGND VPWR VPWR input1/X sky130_fd_sc_hd__clkbuf_1
X_1336_ _1835_/A _1708_/B VGND VGND VPWR VPWR _2262_/B sky130_fd_sc_hd__nor2_8
XFILLER_45_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_7_i_clk clkbuf_leaf_9_i_clk/A VGND VGND VPWR VPWR _2828_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_42_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2170_ _2001_/D _1782_/Y _2169_/Y _1698_/A VGND VGND VPWR VPWR _2170_/X sky130_fd_sc_hd__o31a_1
XFILLER_2_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1954_ _2009_/B _1930_/Y _2773_/Q _2013_/B VGND VGND VPWR VPWR _1954_/X sky130_fd_sc_hd__a2bb2o_1
X_1885_ _2727_/Q _1899_/B _1883_/X _1884_/X VGND VGND VPWR VPWR _1885_/X sky130_fd_sc_hd__o22a_1
X_2368_ _2822_/Q _1545_/X _2819_/D VGND VGND VPWR VPWR _2822_/D sky130_fd_sc_hd__mux2_1
XFILLER_0_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2437_ _2437_/A VGND VGND VPWR VPWR _2437_/X sky130_fd_sc_hd__buf_8
X_2506_ _2674_/Q _2671_/Q _2561_/S VGND VGND VPWR VPWR _2507_/C sky130_fd_sc_hd__mux2_1
XFILLER_64_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2299_ _2792_/Q _2292_/S _2295_/Y _2825_/Q VGND VGND VPWR VPWR _2792_/D sky130_fd_sc_hd__a22o_1
XPHY_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1319_ _2818_/Q VGND VGND VPWR VPWR _2399_/S sky130_fd_sc_hd__buf_12
XPHY_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1670_ _2715_/Q _1669_/X _2172_/A VGND VGND VPWR VPWR _2083_/B sky130_fd_sc_hd__o21ai_4
X_2222_ _2016_/S _2218_/X _2221_/X _2272_/C VGND VGND VPWR VPWR _2222_/X sky130_fd_sc_hd__o211a_1
XFILLER_23_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2153_ _2619_/Q _1678_/D _2093_/Y _2209_/A VGND VGND VPWR VPWR _2153_/X sky130_fd_sc_hd__o211a_1
XFILLER_38_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2084_ _2087_/A _2084_/B _2086_/B VGND VGND VPWR VPWR _2712_/D sky130_fd_sc_hd__or3b_1
X_1937_ _1496_/A _1765_/Y _1936_/X _2262_/B VGND VGND VPWR VPWR _1937_/X sky130_fd_sc_hd__a211o_1
XFILLER_21_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1868_ _2733_/Q _1763_/B _1867_/X _2012_/A VGND VGND VPWR VPWR _1868_/X sky130_fd_sc_hd__a211o_1
X_1799_ _2667_/Q _1798_/X _1982_/S VGND VGND VPWR VPWR _2667_/D sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_10_i_clk clkbuf_leaf_9_i_clk/A VGND VGND VPWR VPWR _2837_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_16_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_25_i_clk clkbuf_2_1__f_i_clk/X VGND VGND VPWR VPWR _2883_/CLK sky130_fd_sc_hd__clkbuf_16
X_2840_ _2844_/CLK _2840_/D VGND VGND VPWR VPWR _2840_/Q sky130_fd_sc_hd__dfxtp_1
X_2771_ _2828_/CLK _2771_/D VGND VGND VPWR VPWR _2771_/Q sky130_fd_sc_hd__dfxtp_1
X_1584_ _2639_/Q _1583_/X _1598_/S VGND VGND VPWR VPWR _2639_/D sky130_fd_sc_hd__mux2_1
X_1653_ _1914_/B VGND VGND VPWR VPWR _1730_/A sky130_fd_sc_hd__inv_2
XTAP_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1722_ _1698_/A _1733_/B _1720_/X _1721_/Y VGND VGND VPWR VPWR _1723_/B sky130_fd_sc_hd__a31o_1
XFILLER_7_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2205_ _2205_/A _2205_/B _2205_/C _2205_/D VGND VGND VPWR VPWR _2205_/X sky130_fd_sc_hd__or4_1
XFILLER_41_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2067_ _2706_/Q _2083_/B VGND VGND VPWR VPWR _2067_/Y sky130_fd_sc_hd__nand2_1
XFILLER_26_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2136_ _2685_/Q _2687_/Q _2686_/Q _2688_/Q VGND VGND VPWR VPWR _2136_/X sky130_fd_sc_hd__or4bb_1
XFILLER_27_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2823_ _2824_/CLK _2823_/D VGND VGND VPWR VPWR _2823_/Q sky130_fd_sc_hd__dfxtp_1
X_1705_ _1705_/A VGND VGND VPWR VPWR _1787_/A sky130_fd_sc_hd__buf_6
X_2754_ _2897_/CLK _2754_/D VGND VGND VPWR VPWR _2754_/Q sky130_fd_sc_hd__dfxtp_1
X_1567_ _2630_/Q _2627_/Q _2399_/S VGND VGND VPWR VPWR _1567_/X sky130_fd_sc_hd__mux2_1
X_1636_ _2009_/B _1636_/B _1686_/B _2129_/C VGND VGND VPWR VPWR _1637_/B sky130_fd_sc_hd__or4b_1
XTAP_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2685_ _2883_/CLK _2685_/D VGND VGND VPWR VPWR _2685_/Q sky130_fd_sc_hd__dfxtp_2
XFILLER_58_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2119_ _2733_/Q _1496_/A _2121_/S VGND VGND VPWR VPWR _2733_/D sky130_fd_sc_hd__mux2_1
X_1498_ _1498_/A _1498_/B VGND VGND VPWR VPWR _1511_/B sky130_fd_sc_hd__xnor2_1
XTAP_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1421_ _2691_/Q _1420_/Y _2193_/A VGND VGND VPWR VPWR _1421_/Y sky130_fd_sc_hd__a21oi_1
X_2470_ _2867_/Q _2423_/X _2467_/X _2469_/X VGND VGND VPWR VPWR _2867_/D sky130_fd_sc_hd__o22a_1
XFILLER_55_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1352_ _1352_/A VGND VGND VPWR VPWR _2205_/B sky130_fd_sc_hd__buf_6
XFILLER_63_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2806_ _2853_/CLK _2806_/D VGND VGND VPWR VPWR _2806_/Q sky130_fd_sc_hd__dfxtp_1
X_2737_ _2777_/CLK _2737_/D VGND VGND VPWR VPWR _2737_/Q sky130_fd_sc_hd__dfxtp_2
X_2668_ _2724_/CLK _2668_/D VGND VGND VPWR VPWR _2668_/Q sky130_fd_sc_hd__dfxtp_1
X_1619_ _2090_/A _2090_/B VGND VGND VPWR VPWR _1620_/A sky130_fd_sc_hd__and2_1
X_2599_ _2690_/Q _2689_/Q _2447_/A _2582_/A _2598_/Y VGND VGND VPWR VPWR _2599_/X
+ sky130_fd_sc_hd__a32o_1
XFILLER_27_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1970_ _2205_/B _2272_/B VGND VGND VPWR VPWR _1990_/B sky130_fd_sc_hd__nand2_1
XFILLER_53_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2522_ _2606_/A _2874_/Q _2343_/X _2521_/X VGND VGND VPWR VPWR _2522_/X sky130_fd_sc_hd__o211a_1
X_2384_ _2838_/Q _1579_/X _2819_/D VGND VGND VPWR VPWR _2838_/D sky130_fd_sc_hd__mux2_1
X_1335_ _1335_/A VGND VGND VPWR VPWR _1708_/B sky130_fd_sc_hd__buf_4
X_1404_ _1639_/A _1838_/B VGND VGND VPWR VPWR _1712_/B sky130_fd_sc_hd__nor2_4
X_2453_ _2863_/Q _2860_/Q _2571_/A VGND VGND VPWR VPWR _2453_/X sky130_fd_sc_hd__mux2_1
Xinput2 i_qspi_dat[1] VGND VGND VPWR VPWR input2/X sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_24_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1884_ _2735_/Q _1763_/B _2012_/A VGND VGND VPWR VPWR _1884_/X sky130_fd_sc_hd__a21o_1
X_1953_ _1782_/A _1941_/B _2686_/Q _1782_/Y VGND VGND VPWR VPWR _1953_/X sky130_fd_sc_hd__a22o_1
XFILLER_33_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2505_ _2874_/Q _2423_/X _2502_/X _2504_/X VGND VGND VPWR VPWR _2874_/D sky130_fd_sc_hd__o22a_1
X_2298_ _2791_/Q _2292_/S _2295_/Y _2824_/Q VGND VGND VPWR VPWR _2791_/D sky130_fd_sc_hd__a22o_1
XFILLER_56_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2367_ _2594_/B _2337_/Y _2410_/A VGND VGND VPWR VPWR _2820_/D sky130_fd_sc_hd__a21o_1
X_1318_ _2817_/Q _2738_/Q VGND VGND VPWR VPWR _1318_/X sky130_fd_sc_hd__or2_1
X_2436_ _2820_/Q _2334_/B _1311_/B _2410_/A VGND VGND VPWR VPWR _2437_/A sky130_fd_sc_hd__a31o_1
XPHY_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2152_ _2152_/A _2152_/B _2152_/C _2083_/B VGND VGND VPWR VPWR _2152_/X sky130_fd_sc_hd__or4b_1
X_2221_ _1698_/A _2219_/X _2220_/Y _1712_/B _2262_/B VGND VGND VPWR VPWR _2221_/X
+ sky130_fd_sc_hd__a2111o_1
XFILLER_16_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2083_ _2083_/A _2083_/B VGND VGND VPWR VPWR _2086_/B sky130_fd_sc_hd__or2_1
X_1936_ _1698_/A _1933_/X _1935_/X VGND VGND VPWR VPWR _1936_/X sky130_fd_sc_hd__o21a_1
X_1867_ _2763_/Q _1943_/S _1865_/X _1866_/X _1841_/Y VGND VGND VPWR VPWR _1867_/X
+ sky130_fd_sc_hd__o221a_1
Xinput60 i_wb_we VGND VGND VPWR VPWR _1326_/A sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_6_i_clk clkbuf_leaf_9_i_clk/A VGND VGND VPWR VPWR _2824_/CLK sky130_fd_sc_hd__clkbuf_16
X_1798_ _2667_/Q _2402_/S _1740_/A _1795_/X _1797_/X VGND VGND VPWR VPWR _1798_/X
+ sky130_fd_sc_hd__a311o_1
XFILLER_44_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2419_ _2419_/A _2582_/A VGND VGND VPWR VPWR _2419_/Y sky130_fd_sc_hd__nor2_1
XFILLER_29_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2770_ _2824_/CLK _2770_/D VGND VGND VPWR VPWR _2770_/Q sky130_fd_sc_hd__dfxtp_1
X_1721_ _2402_/S _1726_/A _1928_/A _1641_/Y VGND VGND VPWR VPWR _1721_/Y sky130_fd_sc_hd__o31ai_1
X_1583_ _2638_/Q _2635_/Q _2399_/S VGND VGND VPWR VPWR _1583_/X sky130_fd_sc_hd__mux2_1
X_1652_ _2129_/D _1652_/B VGND VGND VPWR VPWR _2260_/B sky130_fd_sc_hd__nor2_2
XTAP_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2135_ _2135_/A _2135_/B _1984_/A VGND VGND VPWR VPWR _2135_/X sky130_fd_sc_hd__or3b_1
X_2204_ _2000_/A _2201_/Y _2202_/X _2203_/X VGND VGND VPWR VPWR _2204_/X sky130_fd_sc_hd__a31o_1
XFILLER_26_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2066_ _2706_/Q _2083_/B VGND VGND VPWR VPWR _2072_/C sky130_fd_sc_hd__or2_1
X_1919_ _2682_/Q _1918_/X _1982_/S VGND VGND VPWR VPWR _2682_/D sky130_fd_sc_hd__mux2_1
XFILLER_43_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2822_ _2838_/CLK _2822_/D VGND VGND VPWR VPWR _2822_/Q sky130_fd_sc_hd__dfxtp_2
XFILLER_31_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1704_ _1914_/B _1784_/C _1706_/B VGND VGND VPWR VPWR _1705_/A sky130_fd_sc_hd__and3_1
X_2753_ _2897_/CLK _2753_/D VGND VGND VPWR VPWR _2753_/Q sky130_fd_sc_hd__dfxtp_1
X_2684_ _2883_/CLK _2684_/D VGND VGND VPWR VPWR _2684_/Q sky130_fd_sc_hd__dfxtp_1
X_1566_ _2630_/Q _1565_/X _1598_/S VGND VGND VPWR VPWR _2630_/D sky130_fd_sc_hd__mux2_1
X_1497_ _2731_/Q _1469_/A _1493_/C VGND VGND VPWR VPWR _1498_/B sky130_fd_sc_hd__o21ba_1
X_1635_ _2123_/A _1635_/B _1635_/C VGND VGND VPWR VPWR _2129_/C sky130_fd_sc_hd__nor3_1
XTAP_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2118_ _2732_/Q _1457_/A _2121_/S VGND VGND VPWR VPWR _2732_/D sky130_fd_sc_hd__mux2_1
XTAP_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2049_ _2044_/X _2700_/Q _2064_/S VGND VGND VPWR VPWR _2050_/B sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_24_i_clk clkbuf_2_1__f_i_clk/X VGND VGND VPWR VPWR _2889_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_13_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1420_ _2261_/B VGND VGND VPWR VPWR _1420_/Y sky130_fd_sc_hd__inv_2
X_1351_ _2090_/A _1696_/B VGND VGND VPWR VPWR _1352_/A sky130_fd_sc_hd__or2_1
X_2805_ _2853_/CLK _2805_/D VGND VGND VPWR VPWR _2805_/Q sky130_fd_sc_hd__dfxtp_1
X_1618_ _2819_/Q _2135_/B _1616_/X _2188_/B VGND VGND VPWR VPWR _1622_/B sky130_fd_sc_hd__a31o_1
X_2736_ _2775_/CLK _2736_/D VGND VGND VPWR VPWR _2736_/Q sky130_fd_sc_hd__dfxtp_4
X_2667_ _2724_/CLK _2667_/D VGND VGND VPWR VPWR _2667_/Q sky130_fd_sc_hd__dfxtp_1
X_1549_ _2621_/Q input2/X _2399_/S VGND VGND VPWR VPWR _1549_/X sky130_fd_sc_hd__mux2_1
X_2598_ _2893_/Q _2598_/B VGND VGND VPWR VPWR _2598_/Y sky130_fd_sc_hd__xnor2_1
XFILLER_54_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2521_ _2571_/A _2877_/Q VGND VGND VPWR VPWR _2521_/X sky130_fd_sc_hd__or2_1
X_2383_ _2837_/Q _1577_/X _2819_/D VGND VGND VPWR VPWR _2837_/D sky130_fd_sc_hd__mux2_1
XFILLER_46_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1334_ _1988_/A _1639_/A VGND VGND VPWR VPWR _1335_/A sky130_fd_sc_hd__or2_1
X_1403_ _1403_/A VGND VGND VPWR VPWR _1838_/B sky130_fd_sc_hd__clkbuf_4
X_2452_ _2562_/A _2594_/B _2452_/C VGND VGND VPWR VPWR _2452_/X sky130_fd_sc_hd__and3_1
Xinput3 i_qspi_dat[2] VGND VGND VPWR VPWR input3/X sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_51_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2719_ _2724_/CLK _2719_/D VGND VGND VPWR VPWR _2719_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_10_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1883_ _2765_/Q _1882_/X _1943_/S VGND VGND VPWR VPWR _1883_/X sky130_fd_sc_hd__mux2_1
X_1952_ _2685_/Q _1926_/B _1948_/X _1951_/Y VGND VGND VPWR VPWR _2685_/D sky130_fd_sc_hd__a22o_1
XFILLER_14_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2435_ _2860_/Q _2889_/Q _2571_/A VGND VGND VPWR VPWR _2435_/X sky130_fd_sc_hd__mux2_1
X_2504_ _2674_/Q _2419_/A _2588_/B _2503_/X _2437_/X VGND VGND VPWR VPWR _2504_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_56_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2366_ _2400_/S VGND VGND VPWR VPWR _2819_/D sky130_fd_sc_hd__clkbuf_16
X_2297_ _2790_/Q _2292_/S _2295_/Y _2823_/Q VGND VGND VPWR VPWR _2790_/D sky130_fd_sc_hd__a22o_1
XFILLER_2_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1317_ _2820_/Q _2618_/Q _2738_/Q VGND VGND VPWR VPWR _1317_/X sky130_fd_sc_hd__mux2_1
XPHY_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_30 _2750_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2151_ _1727_/C _1732_/X _2150_/X _1733_/Y VGND VGND VPWR VPWR _2152_/C sky130_fd_sc_hd__a211o_1
X_2220_ _2210_/A _2126_/A _2184_/X _1932_/A VGND VGND VPWR VPWR _2220_/Y sky130_fd_sc_hd__a31oi_1
X_2082_ _2711_/Q _2079_/A _2712_/Q VGND VGND VPWR VPWR _2084_/B sky130_fd_sc_hd__o21a_1
XFILLER_53_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput50 i_wb_data[30] VGND VGND VPWR VPWR input50/X sky130_fd_sc_hd__clkbuf_1
X_1935_ _2684_/Q _1782_/Y _1934_/Y _2205_/B VGND VGND VPWR VPWR _1935_/X sky130_fd_sc_hd__a211o_1
X_1866_ _2703_/Q _2123_/B _2614_/B _2747_/Q _2013_/B VGND VGND VPWR VPWR _1866_/X
+ sky130_fd_sc_hd__a221o_1
X_1797_ _2667_/Q _1787_/A _1796_/X VGND VGND VPWR VPWR _1797_/X sky130_fd_sc_hd__a21o_1
X_2418_ _2856_/Q _2323_/B _2606_/B VGND VGND VPWR VPWR _2582_/A sky130_fd_sc_hd__a21o_1
XFILLER_37_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2349_ _2349_/A _2349_/B VGND VGND VPWR VPWR _2415_/C sky130_fd_sc_hd__and2_1
XFILLER_16_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1720_ _1782_/A _2205_/C _1717_/Y _1719_/Y _2001_/D VGND VGND VPWR VPWR _1720_/X
+ sky130_fd_sc_hd__a311o_1
X_1651_ _1646_/X _1738_/A _2142_/C _2188_/A VGND VGND VPWR VPWR _1651_/X sky130_fd_sc_hd__a211o_1
XFILLER_7_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1582_ _2638_/Q _1581_/X _1598_/S VGND VGND VPWR VPWR _2638_/D sky130_fd_sc_hd__mux2_1
XTAP_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2203_ _2655_/Q _2186_/B _2186_/A VGND VGND VPWR VPWR _2203_/X sky130_fd_sc_hd__o21a_1
XTAP_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2134_ _2741_/Q _1736_/B _1709_/X _1983_/X VGND VGND VPWR VPWR _2135_/A sky130_fd_sc_hd__o22ai_1
X_2065_ _2272_/C _2065_/B VGND VGND VPWR VPWR _2705_/D sky130_fd_sc_hd__and2_1
XFILLER_34_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1849_ _2759_/Q _2027_/S VGND VGND VPWR VPWR _1849_/X sky130_fd_sc_hd__and2_1
X_1918_ _1498_/A _1765_/Y _1911_/X _1913_/X _1917_/X VGND VGND VPWR VPWR _1918_/X
+ sky130_fd_sc_hd__a2111o_1
XFILLER_40_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_5_i_clk clkbuf_leaf_9_i_clk/A VGND VGND VPWR VPWR _2775_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_0_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2821_ _2897_/CLK _2821_/D VGND VGND VPWR VPWR _2821_/Q sky130_fd_sc_hd__dfxtp_4
X_1634_ _1684_/B _2211_/A _2012_/A _2087_/A VGND VGND VPWR VPWR _1635_/C sky130_fd_sc_hd__or4_1
X_1703_ _1703_/A VGND VGND VPWR VPWR _1706_/B sky130_fd_sc_hd__buf_2
X_2683_ _2683_/CLK _2683_/D VGND VGND VPWR VPWR _2683_/Q sky130_fd_sc_hd__dfxtp_1
X_2752_ _2897_/CLK _2752_/D VGND VGND VPWR VPWR _2752_/Q sky130_fd_sc_hd__dfxtp_1
X_1565_ _2629_/Q _2626_/Q _2399_/S VGND VGND VPWR VPWR _1565_/X sky130_fd_sc_hd__mux2_1
X_1496_ _1496_/A _1496_/B VGND VGND VPWR VPWR _1511_/A sky130_fd_sc_hd__xnor2_1
XFILLER_39_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2117_ _2731_/Q _1498_/A _2121_/S VGND VGND VPWR VPWR _2731_/D sky130_fd_sc_hd__mux2_1
X_2048_ _2048_/A _2610_/B VGND VGND VPWR VPWR _2064_/S sky130_fd_sc_hd__nand2_2
XFILLER_22_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1350_ _1630_/A _2272_/A VGND VGND VPWR VPWR _1696_/B sky130_fd_sc_hd__or2_1
XFILLER_63_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2804_ _2853_/CLK _2804_/D VGND VGND VPWR VPWR _2804_/Q sky130_fd_sc_hd__dfxtp_1
X_1617_ _1708_/A _1617_/B VGND VGND VPWR VPWR _2188_/B sky130_fd_sc_hd__and2_1
X_2735_ _2854_/CLK _2735_/D VGND VGND VPWR VPWR _2735_/Q sky130_fd_sc_hd__dfxtp_2
X_2597_ _2892_/Q _2600_/S _2596_/X VGND VGND VPWR VPWR _2892_/D sky130_fd_sc_hd__a21bo_1
X_2666_ _2683_/CLK _2666_/D VGND VGND VPWR VPWR _2666_/Q sky130_fd_sc_hd__dfxtp_1
X_1548_ _2621_/Q _1545_/X _1598_/S VGND VGND VPWR VPWR _2621_/D sky130_fd_sc_hd__mux2_1
X_1479_ _2716_/Q _2717_/Q VGND VGND VPWR VPWR _1934_/B sky130_fd_sc_hd__nand2_4
XFILLER_24_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2451_ _2663_/Q _2660_/Q _2561_/S VGND VGND VPWR VPWR _2452_/C sky130_fd_sc_hd__mux2_1
XFILLER_5_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_23_i_clk clkbuf_2_1__f_i_clk/X VGND VGND VPWR VPWR _2884_/CLK sky130_fd_sc_hd__clkbuf_16
X_2520_ _2877_/Q _2423_/X _2517_/X _2519_/X VGND VGND VPWR VPWR _2877_/D sky130_fd_sc_hd__o22a_1
X_1402_ _1630_/A _1988_/A VGND VGND VPWR VPWR _1403_/A sky130_fd_sc_hd__or2b_1
X_2382_ _2836_/Q _1575_/X _2819_/D VGND VGND VPWR VPWR _2836_/D sky130_fd_sc_hd__mux2_1
Xinput4 i_qspi_dat[3] VGND VGND VPWR VPWR input4/X sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_39_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1333_ _2742_/Q _2741_/Q VGND VGND VPWR VPWR _1639_/A sky130_fd_sc_hd__or2_2
XFILLER_51_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2718_ _2876_/CLK _2718_/D VGND VGND VPWR VPWR _2718_/Q sky130_fd_sc_hd__dfxtp_1
X_2649_ _2850_/CLK _2649_/D VGND VGND VPWR VPWR _2649_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_19_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1882_ _2763_/Q _2027_/S _2123_/B _2896_/Q _2612_/A VGND VGND VPWR VPWR _1882_/X
+ sky130_fd_sc_hd__a221o_1
X_1951_ _2262_/B _1950_/X _1926_/B VGND VGND VPWR VPWR _1951_/Y sky130_fd_sc_hd__a21oi_1
XFILLER_14_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2434_ _2562_/A _2594_/B _2434_/C VGND VGND VPWR VPWR _2434_/X sky130_fd_sc_hd__and3_1
X_2503_ _2673_/Q _2670_/Q _2655_/Q VGND VGND VPWR VPWR _2503_/X sky130_fd_sc_hd__mux2_1
X_2365_ _2365_/A _2365_/B VGND VGND VPWR VPWR _2400_/S sky130_fd_sc_hd__nor2_8
X_2296_ _2789_/Q _2292_/S _2295_/Y _2822_/Q VGND VGND VPWR VPWR _2789_/D sky130_fd_sc_hd__a22o_1
XFILLER_49_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1316_ _2653_/Q _1309_/Y _1315_/X VGND VGND VPWR VPWR _2821_/D sky130_fd_sc_hd__a21oi_1
XPHY_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_20 _2671_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_31 _2349_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2150_ _2150_/A _2150_/B _2150_/C _2150_/D VGND VGND VPWR VPWR _2150_/X sky130_fd_sc_hd__or4_1
X_2081_ _2711_/Q _2079_/A _2080_/Y VGND VGND VPWR VPWR _2711_/D sky130_fd_sc_hd__a21o_1
X_1934_ _2205_/A _1934_/B VGND VGND VPWR VPWR _1934_/Y sky130_fd_sc_hd__nor2_2
Xinput51 i_wb_data[31] VGND VGND VPWR VPWR _1731_/A sky130_fd_sc_hd__clkbuf_2
Xinput40 i_wb_data[21] VGND VGND VPWR VPWR input40/X sky130_fd_sc_hd__clkbuf_1
X_1865_ _2761_/Q _2027_/S VGND VGND VPWR VPWR _1865_/X sky130_fd_sc_hd__and2_1
X_1796_ _2193_/B _1471_/A _1784_/C _1765_/Y input5/X VGND VGND VPWR VPWR _1796_/X
+ sky130_fd_sc_hd__a32o_1
X_2348_ _2571_/A VGND VGND VPWR VPWR _2606_/A sky130_fd_sc_hd__inv_4
X_2417_ _2447_/A VGND VGND VPWR VPWR _2419_/A sky130_fd_sc_hd__buf_8
X_2279_ _2838_/Q _2304_/B _2295_/B _2695_/Q VGND VGND VPWR VPWR _2279_/X sky130_fd_sc_hd__a22o_1
XFILLER_52_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1581_ _2637_/Q _2634_/Q _2399_/S VGND VGND VPWR VPWR _1581_/X sky130_fd_sc_hd__mux2_1
X_1650_ _1418_/A _2822_/Q _1712_/B _2090_/A VGND VGND VPWR VPWR _2142_/C sky130_fd_sc_hd__o211a_1
XFILLER_7_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2202_ _2202_/A _2202_/B _2742_/Q VGND VGND VPWR VPWR _2202_/X sky130_fd_sc_hd__or3b_1
XFILLER_3_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2133_ _1914_/B _2609_/A _2247_/S _2737_/Q VGND VGND VPWR VPWR _2737_/D sky130_fd_sc_hd__o22a_1
X_2064_ _2063_/X _2705_/Q _2064_/S VGND VGND VPWR VPWR _2065_/B sky130_fd_sc_hd__mux2_1
XFILLER_19_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1917_ _2682_/Q _1914_/Y _1782_/B _1916_/X VGND VGND VPWR VPWR _1917_/X sky130_fd_sc_hd__o31a_1
X_2897_ _2897_/CLK _2897_/D VGND VGND VPWR VPWR _2897_/Q sky130_fd_sc_hd__dfxtp_1
X_1779_ _1779_/A VGND VGND VPWR VPWR _2123_/B sky130_fd_sc_hd__buf_6
X_1848_ _2193_/B _1498_/A _1784_/C _1765_/Y _1455_/A VGND VGND VPWR VPWR _1848_/X
+ sky130_fd_sc_hd__a32o_1
XFILLER_1_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2820_ _2895_/CLK _2820_/D VGND VGND VPWR VPWR _2820_/Q sky130_fd_sc_hd__dfxtp_4
X_2751_ _2897_/CLK _2751_/D VGND VGND VPWR VPWR _2751_/Q sky130_fd_sc_hd__dfxtp_2
X_1564_ _2629_/Q _1563_/X _1598_/S VGND VGND VPWR VPWR _2629_/D sky130_fd_sc_hd__mux2_1
X_1633_ _1633_/A VGND VGND VPWR VPWR _2087_/A sky130_fd_sc_hd__clkbuf_4
X_1702_ _2691_/Q _2692_/Q VGND VGND VPWR VPWR _1703_/A sky130_fd_sc_hd__or2_1
X_2682_ _2883_/CLK _2682_/D VGND VGND VPWR VPWR _2682_/Q sky130_fd_sc_hd__dfxtp_1
X_1495_ _1495_/A _1495_/B VGND VGND VPWR VPWR _1496_/B sky130_fd_sc_hd__nor2_1
XTAP_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2116_ _2730_/Q _1470_/A _2121_/S VGND VGND VPWR VPWR _2730_/D sky130_fd_sc_hd__mux2_1
X_2047_ _2047_/A _2047_/B VGND VGND VPWR VPWR _2610_/B sky130_fd_sc_hd__nor2_1
XFILLER_22_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2803_ _2844_/CLK _2803_/D VGND VGND VPWR VPWR _2803_/Q sky130_fd_sc_hd__dfxtp_1
X_2734_ _2854_/CLK _2734_/D VGND VGND VPWR VPWR _2734_/Q sky130_fd_sc_hd__dfxtp_2
XFILLER_8_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1547_ _1608_/S VGND VGND VPWR VPWR _1598_/S sky130_fd_sc_hd__clkbuf_16
X_1616_ _2822_/Q _2691_/Q VGND VGND VPWR VPWR _1616_/X sky130_fd_sc_hd__or2b_1
X_2596_ _2690_/Q _2689_/Q _2447_/A _2600_/S _2595_/X VGND VGND VPWR VPWR _2596_/X
+ sky130_fd_sc_hd__a311o_1
X_2665_ _2883_/CLK _2665_/D VGND VGND VPWR VPWR _2665_/Q sky130_fd_sc_hd__dfxtp_1
X_1478_ input6/X _1478_/B VGND VGND VPWR VPWR _1491_/C sky130_fd_sc_hd__xnor2_1
XFILLER_24_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_4_i_clk clkbuf_leaf_9_i_clk/A VGND VGND VPWR VPWR _2742_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_49_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2381_ _2835_/Q _1573_/X _2819_/D VGND VGND VPWR VPWR _2835_/D sky130_fd_sc_hd__mux2_1
X_1401_ _1401_/A VGND VGND VPWR VPWR _1841_/A sky130_fd_sc_hd__buf_4
X_2450_ _2863_/Q _2423_/X _2446_/X _2449_/X VGND VGND VPWR VPWR _2863_/D sky130_fd_sc_hd__o22a_1
XFILLER_5_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1332_ _2743_/Q VGND VGND VPWR VPWR _1988_/A sky130_fd_sc_hd__buf_12
Xinput5 i_wb_addr[0] VGND VGND VPWR VPWR input5/X sky130_fd_sc_hd__clkbuf_4
XFILLER_36_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2717_ _2730_/CLK _2717_/D VGND VGND VPWR VPWR _2717_/Q sky130_fd_sc_hd__dfxtp_4
X_2648_ _2853_/CLK _2648_/D VGND VGND VPWR VPWR _2648_/Q sky130_fd_sc_hd__dfxtp_1
X_2579_ _2577_/Y _2578_/Y _2811_/Q VGND VGND VPWR VPWR _2581_/B sky130_fd_sc_hd__a21oi_1
XFILLER_42_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1950_ _1940_/Y _1914_/Y _1782_/B _1928_/A _2193_/C VGND VGND VPWR VPWR _1950_/X
+ sky130_fd_sc_hd__o32a_1
XFILLER_18_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1881_ _2749_/Q _2614_/B VGND VGND VPWR VPWR _2612_/A sky130_fd_sc_hd__and2_1
X_2502_ _2606_/A _2870_/Q _2343_/X _2501_/X VGND VGND VPWR VPWR _2502_/X sky130_fd_sc_hd__o211a_1
XFILLER_51_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2433_ _2660_/Q _2657_/Q _2561_/S VGND VGND VPWR VPWR _2434_/C sky130_fd_sc_hd__mux2_1
X_2364_ _2399_/S _2361_/X _2363_/X _2355_/Y VGND VGND VPWR VPWR _2818_/D sky130_fd_sc_hd__a22o_1
X_1315_ _2654_/Q _2421_/B _2357_/A _2321_/S VGND VGND VPWR VPWR _1315_/X sky130_fd_sc_hd__o211a_1
XFILLER_64_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2295_ _2403_/S _2295_/B VGND VGND VPWR VPWR _2295_/Y sky130_fd_sc_hd__nor2_2
XFILLER_2_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_21 _2827_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_32 _2870_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_10 i_wb_data[8] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_47_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_22_i_clk clkbuf_2_1__f_i_clk/X VGND VGND VPWR VPWR _2877_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_62_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2080_ _2711_/Q _2079_/A _2272_/C VGND VGND VPWR VPWR _2080_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_61_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1933_ _1900_/D _1931_/X _1932_/X _1899_/B _2733_/Q VGND VGND VPWR VPWR _1933_/X
+ sky130_fd_sc_hd__o32a_1
Xinput41 i_wb_data[22] VGND VGND VPWR VPWR input41/X sky130_fd_sc_hd__clkbuf_1
Xinput30 i_wb_data[12] VGND VGND VPWR VPWR input30/X sky130_fd_sc_hd__clkbuf_1
X_1864_ _2193_/B _1496_/A _1784_/C _1765_/Y _1509_/A VGND VGND VPWR VPWR _1864_/X
+ sky130_fd_sc_hd__a32o_1
X_1795_ _2724_/Q _1763_/B _1794_/X VGND VGND VPWR VPWR _1795_/X sky130_fd_sc_hd__a21o_1
Xinput52 i_wb_data[3] VGND VGND VPWR VPWR input52/X sky130_fd_sc_hd__clkbuf_1
X_2278_ _2277_/X _2780_/Q _2292_/S VGND VGND VPWR VPWR _2780_/D sky130_fd_sc_hd__mux2_1
X_2416_ _2856_/Q _2411_/Y _2415_/X VGND VGND VPWR VPWR _2856_/D sky130_fd_sc_hd__o21a_1
X_2347_ _2813_/Q _2341_/Y _2345_/X _2346_/Y VGND VGND VPWR VPWR _2813_/D sky130_fd_sc_hd__a22o_1
XFILLER_52_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1580_ _2637_/Q _1579_/X _1598_/S VGND VGND VPWR VPWR _2637_/D sky130_fd_sc_hd__mux2_1
XFILLER_11_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2132_ _2255_/S VGND VGND VPWR VPWR _2247_/S sky130_fd_sc_hd__clkbuf_16
XTAP_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2201_ _2127_/D _2210_/B _2200_/Y VGND VGND VPWR VPWR _2201_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_14_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2063_ _2751_/Q _2829_/Q _2615_/B VGND VGND VPWR VPWR _2063_/X sky130_fd_sc_hd__mux2_1
X_1916_ _2264_/A _1914_/B _1915_/Y _2256_/B _2262_/B VGND VGND VPWR VPWR _1916_/X
+ sky130_fd_sc_hd__o311a_1
X_1847_ _2673_/Q _1742_/B _1846_/X _1982_/S VGND VGND VPWR VPWR _2673_/D sky130_fd_sc_hd__a22o_1
X_2896_ _2896_/CLK _2896_/D VGND VGND VPWR VPWR _2896_/Q sky130_fd_sc_hd__dfxtp_1
X_1778_ _2090_/A _2009_/B VGND VGND VPWR VPWR _1779_/A sky130_fd_sc_hd__and2_1
XFILLER_40_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2681_ _2683_/CLK _2681_/D VGND VGND VPWR VPWR _2681_/Q sky130_fd_sc_hd__dfxtp_1
X_2750_ _2816_/CLK _2750_/D VGND VGND VPWR VPWR _2750_/Q sky130_fd_sc_hd__dfxtp_2
X_1701_ _2656_/Q _1695_/Y _1699_/Y _2272_/C VGND VGND VPWR VPWR _2656_/D sky130_fd_sc_hd__o211a_1
X_1563_ _2628_/Q _2625_/Q _2399_/S VGND VGND VPWR VPWR _1563_/X sky130_fd_sc_hd__mux2_1
X_1494_ _2732_/Q _1493_/C _2733_/Q VGND VGND VPWR VPWR _1495_/B sky130_fd_sc_hd__a21oi_1
X_1632_ _1708_/A _1700_/B VGND VGND VPWR VPWR _1633_/A sky130_fd_sc_hd__and2_1
XTAP_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2115_ _2729_/Q input9/X _2121_/S VGND VGND VPWR VPWR _2729_/D sky130_fd_sc_hd__mux2_1
XTAP_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2046_ _2046_/A _2211_/A _2262_/A _2046_/D VGND VGND VPWR VPWR _2047_/B sky130_fd_sc_hd__or4_1
XFILLER_22_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2879_ _2884_/CLK _2879_/D VGND VGND VPWR VPWR _2879_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_38_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2802_ _2836_/CLK _2802_/D VGND VGND VPWR VPWR _2802_/Q sky130_fd_sc_hd__dfxtp_1
X_2733_ _2854_/CLK _2733_/D VGND VGND VPWR VPWR _2733_/Q sky130_fd_sc_hd__dfxtp_2
X_2664_ _2876_/CLK _2664_/D VGND VGND VPWR VPWR _2664_/Q sky130_fd_sc_hd__dfxtp_1
X_1615_ _2090_/A _1627_/A _1988_/A _1630_/A VGND VGND VPWR VPWR _2135_/B sky130_fd_sc_hd__and4bb_2
X_1477_ _2726_/Q _1508_/A VGND VGND VPWR VPWR _1478_/B sky130_fd_sc_hd__xnor2_1
XFILLER_5_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1546_ _2365_/A _2334_/B VGND VGND VPWR VPWR _1608_/S sky130_fd_sc_hd__nor2_4
X_2595_ _2588_/A _2562_/A _2594_/B _2593_/X _2594_/Y VGND VGND VPWR VPWR _2595_/X
+ sky130_fd_sc_hd__o221a_1
XFILLER_54_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2029_ _2730_/Q VGND VGND VPWR VPWR _2029_/Y sky130_fd_sc_hd__inv_2
XFILLER_35_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2380_ _2834_/Q _1571_/X _2819_/D VGND VGND VPWR VPWR _2834_/D sky130_fd_sc_hd__mux2_1
X_1331_ _1331_/A VGND VGND VPWR VPWR _1835_/A sky130_fd_sc_hd__buf_6
XFILLER_30_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1400_ _1988_/A _1988_/B VGND VGND VPWR VPWR _1401_/A sky130_fd_sc_hd__and2_1
XFILLER_5_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput6 i_wb_addr[10] VGND VGND VPWR VPWR input6/X sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_51_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2647_ _2854_/CLK _2647_/D VGND VGND VPWR VPWR _2647_/Q sky130_fd_sc_hd__dfxtp_1
X_2716_ _2730_/CLK _2716_/D VGND VGND VPWR VPWR _2716_/Q sky130_fd_sc_hd__dfxtp_4
XFILLER_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1529_ _1988_/C _2258_/A _1526_/Y _1528_/Y VGND VGND VPWR VPWR _1529_/X sky130_fd_sc_hd__a211o_1
X_2578_ _2895_/Q VGND VGND VPWR VPWR _2578_/Y sky130_fd_sc_hd__inv_2
XFILLER_35_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1880_ _2193_/B _1448_/A _1784_/C _1765_/Y input7/X VGND VGND VPWR VPWR _1880_/X
+ sky130_fd_sc_hd__a32o_1
X_2501_ _2571_/A _2873_/Q VGND VGND VPWR VPWR _2501_/X sky130_fd_sc_hd__or2_1
X_2294_ _2293_/X _2788_/Q _2403_/S VGND VGND VPWR VPWR _2788_/D sky130_fd_sc_hd__mux2_1
XFILLER_44_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2432_ _2660_/Q _2562_/A _2583_/B _2860_/Q _2431_/X VGND VGND VPWR VPWR _2860_/D
+ sky130_fd_sc_hd__o221a_1
XFILLER_2_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2363_ _2571_/A _2606_/B _2344_/X VGND VGND VPWR VPWR _2363_/X sky130_fd_sc_hd__a21o_1
X_1314_ _2365_/B _1311_/B _2365_/A VGND VGND VPWR VPWR _2321_/S sky130_fd_sc_hd__a21oi_2
XFILLER_64_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_3_i_clk clkbuf_leaf_3_i_clk/A VGND VGND VPWR VPWR _2743_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_2_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_22 _2811_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_33 _2862_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_11 _2707_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_55_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput31 i_wb_data[13] VGND VGND VPWR VPWR input31/X sky130_fd_sc_hd__clkbuf_1
X_1863_ _2675_/Q _1742_/B _1862_/X _1982_/S VGND VGND VPWR VPWR _2675_/D sky130_fd_sc_hd__a22o_1
X_1932_ _1932_/A _1932_/B VGND VGND VPWR VPWR _1932_/X sky130_fd_sc_hd__and2_1
Xinput20 i_wb_addr[5] VGND VGND VPWR VPWR _1461_/A sky130_fd_sc_hd__clkbuf_2
Xinput42 i_wb_data[23] VGND VGND VPWR VPWR input42/X sky130_fd_sc_hd__clkbuf_1
Xinput53 i_wb_data[4] VGND VGND VPWR VPWR input53/X sky130_fd_sc_hd__clkbuf_1
X_2415_ _2415_/A _2415_/B _2415_/C _2415_/D VGND VGND VPWR VPWR _2415_/X sky130_fd_sc_hd__or4_1
X_1794_ _2746_/Q _2123_/B _1793_/X VGND VGND VPWR VPWR _1794_/X sky130_fd_sc_hd__a21o_1
X_2277_ _2837_/Q _2304_/B _2295_/B _2694_/Q VGND VGND VPWR VPWR _2277_/X sky130_fd_sc_hd__a22o_1
X_2346_ _2346_/A VGND VGND VPWR VPWR _2346_/Y sky130_fd_sc_hd__inv_2
XFILLER_52_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2131_ _2131_/A VGND VGND VPWR VPWR _2255_/S sky130_fd_sc_hd__clkbuf_4
XTAP_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2062_ _2272_/C _2062_/B VGND VGND VPWR VPWR _2704_/D sky130_fd_sc_hd__and2_1
X_2200_ _1897_/B _1934_/Y _1841_/A VGND VGND VPWR VPWR _2200_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_34_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1915_ _1928_/B VGND VGND VPWR VPWR _1915_/Y sky130_fd_sc_hd__inv_2
X_1846_ _2673_/Q _1787_/A _1844_/X _1845_/X VGND VGND VPWR VPWR _1846_/X sky130_fd_sc_hd__a211o_1
X_2895_ _2895_/CLK _2895_/D VGND VGND VPWR VPWR _2895_/Q sky130_fd_sc_hd__dfxtp_1
X_1777_ _2664_/Q _1742_/B _1776_/X _1982_/S VGND VGND VPWR VPWR _2664_/D sky130_fd_sc_hd__a22o_1
XFILLER_1_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_21_i_clk clkbuf_2_1__f_i_clk/X VGND VGND VPWR VPWR _2876_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_57_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2329_ _2857_/Q _2412_/B _1311_/B _2410_/A _2447_/A VGND VGND VPWR VPWR _2346_/A
+ sky130_fd_sc_hd__a311o_2
XFILLER_4_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1700_ _1708_/A _1700_/B VGND VGND VPWR VPWR _2272_/C sky130_fd_sc_hd__nand2_8
X_2680_ _2883_/CLK _2680_/D VGND VGND VPWR VPWR _2680_/Q sky130_fd_sc_hd__dfxtp_1
X_1631_ _1835_/A _2272_/A VGND VGND VPWR VPWR _2012_/A sky130_fd_sc_hd__nor2_8
X_1562_ _2628_/Q _1561_/X _1598_/S VGND VGND VPWR VPWR _2628_/D sky130_fd_sc_hd__mux2_1
X_1493_ _2732_/Q _2733_/Q _1493_/C VGND VGND VPWR VPWR _1495_/A sky130_fd_sc_hd__and3_1
XTAP_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2114_ _2728_/Q input8/X _2121_/S VGND VGND VPWR VPWR _2728_/D sky130_fd_sc_hd__mux2_1
XFILLER_39_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2045_ _2009_/A _2614_/B _2123_/B _2127_/A VGND VGND VPWR VPWR _2046_/D sky130_fd_sc_hd__a211o_1
XTAP_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2878_ _2884_/CLK _2878_/D VGND VGND VPWR VPWR _2878_/Q sky130_fd_sc_hd__dfxtp_1
X_1829_ _2751_/Q _2123_/B _1828_/X VGND VGND VPWR VPWR _1829_/X sky130_fd_sc_hd__a21o_1
XFILLER_38_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2801_ _2836_/CLK _2801_/D VGND VGND VPWR VPWR _2801_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_44_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2732_ _2854_/CLK _2732_/D VGND VGND VPWR VPWR _2732_/Q sky130_fd_sc_hd__dfxtp_4
X_1614_ _2609_/B _1614_/B VGND VGND VPWR VPWR _1698_/C sky130_fd_sc_hd__nand2_1
XFILLER_8_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2594_ _2690_/Q _2594_/B VGND VGND VPWR VPWR _2594_/Y sky130_fd_sc_hd__nand2_1
X_2663_ _2884_/CLK _2663_/D VGND VGND VPWR VPWR _2663_/Q sky130_fd_sc_hd__dfxtp_1
X_1545_ input2/X input1/X _2399_/S VGND VGND VPWR VPWR _1545_/X sky130_fd_sc_hd__mux2_1
XFILLER_39_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1476_ _2724_/Q _2725_/Q _1476_/C _1476_/D VGND VGND VPWR VPWR _1508_/A sky130_fd_sc_hd__nand4_2
XFILLER_5_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2028_ _2698_/Q VGND VGND VPWR VPWR _2028_/Y sky130_fd_sc_hd__inv_2
XFILLER_50_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1330_ _2090_/A _1630_/A VGND VGND VPWR VPWR _1331_/A sky130_fd_sc_hd__or2b_1
XFILLER_46_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput7 i_wb_addr[11] VGND VGND VPWR VPWR input7/X sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_32_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2646_ _2850_/CLK _2646_/D VGND VGND VPWR VPWR _2646_/Q sky130_fd_sc_hd__dfxtp_1
X_2715_ _2897_/CLK _2715_/D VGND VGND VPWR VPWR _2715_/Q sky130_fd_sc_hd__dfxtp_1
X_2577_ _2894_/Q VGND VGND VPWR VPWR _2577_/Y sky130_fd_sc_hd__inv_2
X_1528_ _2148_/A _2270_/B VGND VGND VPWR VPWR _1528_/Y sky130_fd_sc_hd__nand2_1
X_1459_ _2720_/Q _1476_/C _2721_/Q VGND VGND VPWR VPWR _1461_/C sky130_fd_sc_hd__a21o_1
XFILLER_35_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2431_ _2859_/Q _2424_/Y _2425_/Y _2659_/Q _2426_/Y VGND VGND VPWR VPWR _2431_/X
+ sky130_fd_sc_hd__a221o_1
X_2500_ _2873_/Q _2423_/X _2497_/X _2499_/X VGND VGND VPWR VPWR _2873_/D sky130_fd_sc_hd__o22a_1
X_2293_ _2852_/Q _2304_/B _2295_/B _2699_/Q VGND VGND VPWR VPWR _2293_/X sky130_fd_sc_hd__a22o_1
XFILLER_37_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2362_ _2355_/Y _2360_/X _2361_/X _2817_/Q VGND VGND VPWR VPWR _2817_/D sky130_fd_sc_hd__a22o_1
X_1313_ _2820_/Q VGND VGND VPWR VPWR _2365_/A sky130_fd_sc_hd__inv_2
XFILLER_64_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_34 input3/X VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_23 _2877_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_12 _2709_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2629_ _2829_/CLK _2629_/D VGND VGND VPWR VPWR _2629_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_46_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput43 i_wb_data[24] VGND VGND VPWR VPWR input43/X sky130_fd_sc_hd__clkbuf_1
Xinput54 i_wb_data[5] VGND VGND VPWR VPWR input54/X sky130_fd_sc_hd__clkbuf_1
Xinput10 i_wb_addr[14] VGND VGND VPWR VPWR _1470_/A sky130_fd_sc_hd__clkbuf_2
X_1931_ _2771_/Q _1943_/S _1930_/Y VGND VGND VPWR VPWR _1931_/X sky130_fd_sc_hd__o21a_1
Xinput32 i_wb_data[14] VGND VGND VPWR VPWR input32/X sky130_fd_sc_hd__clkbuf_1
X_1862_ _2675_/Q _1787_/A _1856_/X _1861_/X VGND VGND VPWR VPWR _1862_/X sky130_fd_sc_hd__a211o_1
Xinput21 i_wb_addr[6] VGND VGND VPWR VPWR _1784_/B sky130_fd_sc_hd__clkbuf_2
X_1793_ _2754_/Q _2013_/B _2012_/A _2716_/Q VGND VGND VPWR VPWR _1793_/X sky130_fd_sc_hd__a22o_1
X_2414_ _2404_/Y _2411_/Y _2413_/X _2415_/D _2855_/Q VGND VGND VPWR VPWR _2855_/D
+ sky130_fd_sc_hd__a32o_1
XFILLER_6_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2276_ _2268_/X _2779_/Q _2292_/S VGND VGND VPWR VPWR _2779_/D sky130_fd_sc_hd__mux2_1
X_2345_ _2571_/A _2886_/Q _2343_/X _2344_/X _2686_/Q VGND VGND VPWR VPWR _2345_/X
+ sky130_fd_sc_hd__a32o_1
XFILLER_32_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_2_i_clk clkbuf_leaf_3_i_clk/A VGND VGND VPWR VPWR _2896_/CLK sky130_fd_sc_hd__clkbuf_16
X_2130_ _2130_/A _2130_/B _2130_/C VGND VGND VPWR VPWR _2131_/A sky130_fd_sc_hd__and3_1
X_2061_ _2060_/X _2704_/Q _2064_/S VGND VGND VPWR VPWR _2062_/B sky130_fd_sc_hd__mux2_1
XFILLER_19_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1914_ _2264_/A _1914_/B VGND VGND VPWR VPWR _1914_/Y sky130_fd_sc_hd__nand2_1
X_1845_ _2193_/B _1470_/A _1784_/C _1765_/Y _1784_/B VGND VGND VPWR VPWR _1845_/X
+ sky130_fd_sc_hd__a32o_1
X_2894_ _2895_/CLK _2894_/D VGND VGND VPWR VPWR _2894_/Q sky130_fd_sc_hd__dfxtp_1
X_1776_ _2664_/Q _1787_/A _1763_/B _2721_/Q _1775_/X VGND VGND VPWR VPWR _1776_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_57_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2328_ _2328_/A VGND VGND VPWR VPWR _2447_/A sky130_fd_sc_hd__buf_4
X_2259_ _2259_/A _2259_/B _2271_/B VGND VGND VPWR VPWR _2259_/X sky130_fd_sc_hd__and3_1
XFILLER_4_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1630_ _1630_/A _2272_/A VGND VGND VPWR VPWR _2211_/A sky130_fd_sc_hd__nor2_2
X_1561_ _2627_/Q _2624_/Q _2399_/S VGND VGND VPWR VPWR _1561_/X sky130_fd_sc_hd__mux2_1
X_1492_ _1492_/A _1492_/B _1492_/C _1492_/D VGND VGND VPWR VPWR _1656_/A sky130_fd_sc_hd__and4_1
XTAP_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2113_ _2727_/Q input7/X _2121_/S VGND VGND VPWR VPWR _2727_/D sky130_fd_sc_hd__mux2_1
XFILLER_39_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2044_ _2744_/Q _2822_/Q _2615_/B VGND VGND VPWR VPWR _2044_/X sky130_fd_sc_hd__mux2_1
XFILLER_30_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2877_ _2877_/CLK _2877_/D VGND VGND VPWR VPWR _2877_/Q sky130_fd_sc_hd__dfxtp_1
X_1759_ _2193_/B _1759_/B _1784_/C VGND VGND VPWR VPWR _1759_/X sky130_fd_sc_hd__and3_1
X_1828_ _2759_/Q _2013_/B _2012_/A _2721_/Q VGND VGND VPWR VPWR _1828_/X sky130_fd_sc_hd__a22o_1
XFILLER_57_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2800_ _2836_/CLK _2800_/D VGND VGND VPWR VPWR _2800_/Q sky130_fd_sc_hd__dfxtp_1
X_2731_ _2854_/CLK _2731_/D VGND VGND VPWR VPWR _2731_/Q sky130_fd_sc_hd__dfxtp_2
Xclkbuf_leaf_20_i_clk clkbuf_2_1__f_i_clk/X VGND VGND VPWR VPWR _2724_/CLK sky130_fd_sc_hd__clkbuf_16
X_1544_ _2620_/Q _1419_/Y _1427_/Y _1542_/X _2090_/B VGND VGND VPWR VPWR _2620_/D
+ sky130_fd_sc_hd__a221o_1
X_1613_ _1988_/A _1613_/B VGND VGND VPWR VPWR _1614_/B sky130_fd_sc_hd__nand2_1
X_2662_ _2724_/CLK _2662_/D VGND VGND VPWR VPWR _2662_/Q sky130_fd_sc_hd__dfxtp_1
X_2593_ _2593_/A _2598_/B VGND VGND VPWR VPWR _2593_/X sky130_fd_sc_hd__and2_1
X_1475_ input9/X _1475_/B VGND VGND VPWR VPWR _1491_/B sky130_fd_sc_hd__xnor2_1
XFILLER_54_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2027_ _2698_/Q _2763_/Q _2027_/S VGND VGND VPWR VPWR _2698_/D sky130_fd_sc_hd__mux2_1
XFILLER_45_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput8 i_wb_addr[12] VGND VGND VPWR VPWR input8/X sky130_fd_sc_hd__clkbuf_2
XFILLER_24_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2714_ _2816_/CLK _2714_/D VGND VGND VPWR VPWR _2714_/Q sky130_fd_sc_hd__dfxtp_1
X_2645_ _2853_/CLK _2645_/D VGND VGND VPWR VPWR _2645_/Q sky130_fd_sc_hd__dfxtp_1
X_1527_ _1630_/A _1617_/B VGND VGND VPWR VPWR _2270_/B sky130_fd_sc_hd__nand2_1
X_2576_ _2657_/Q _2419_/A _2437_/X _2889_/Q VGND VGND VPWR VPWR _2889_/D sky130_fd_sc_hd__a22o_1
X_1389_ _1963_/A input5/X VGND VGND VPWR VPWR _1390_/A sky130_fd_sc_hd__or2_1
XFILLER_27_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1458_ _2722_/Q _1461_/B VGND VGND VPWR VPWR _1458_/X sky130_fd_sc_hd__xor2_1
XFILLER_50_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2430_ _2659_/Q _2562_/A _2423_/X _2859_/Q _2429_/X VGND VGND VPWR VPWR _2859_/D
+ sky130_fd_sc_hd__o221a_1
X_2361_ _2410_/A _2361_/B _2415_/B VGND VGND VPWR VPWR _2361_/X sky130_fd_sc_hd__or3_1
X_2292_ _2291_/X _2787_/Q _2292_/S VGND VGND VPWR VPWR _2787_/D sky130_fd_sc_hd__mux2_1
XFILLER_2_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1312_ _2821_/Q _2653_/Q VGND VGND VPWR VPWR _2357_/A sky130_fd_sc_hd__or2b_1
XFILLER_64_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_13 _2873_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_35 _1731_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_24 _2620_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2628_ _2829_/CLK _2628_/D VGND VGND VPWR VPWR _2628_/Q sky130_fd_sc_hd__dfxtp_1
X_2559_ _2685_/Q _2419_/A _2343_/X _2558_/X _2437_/X VGND VGND VPWR VPWR _2559_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_55_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1930_ _1943_/S _2609_/B VGND VGND VPWR VPWR _1930_/Y sky130_fd_sc_hd__nand2_2
Xinput44 i_wb_data[25] VGND VGND VPWR VPWR input44/X sky130_fd_sc_hd__clkbuf_1
Xinput11 i_wb_addr[15] VGND VGND VPWR VPWR _1498_/A sky130_fd_sc_hd__clkbuf_2
Xinput55 i_wb_data[6] VGND VGND VPWR VPWR input55/X sky130_fd_sc_hd__clkbuf_1
X_1861_ _2724_/Q _1899_/B _1860_/X VGND VGND VPWR VPWR _1861_/X sky130_fd_sc_hd__o21a_1
Xinput33 i_wb_data[15] VGND VGND VPWR VPWR input33/X sky130_fd_sc_hd__clkbuf_1
Xinput22 i_wb_addr[7] VGND VGND VPWR VPWR _1455_/A sky130_fd_sc_hd__clkbuf_2
X_1792_ _2666_/Q _1787_/X _1791_/X _1982_/S VGND VGND VPWR VPWR _2666_/D sky130_fd_sc_hd__a22o_1
X_2413_ _2365_/B _2412_/Y _2361_/B _1672_/Y VGND VGND VPWR VPWR _2413_/X sky130_fd_sc_hd__a22o_1
X_2344_ _2561_/S _2349_/A _2349_/B VGND VGND VPWR VPWR _2344_/X sky130_fd_sc_hd__and3_1
X_2275_ _2403_/S VGND VGND VPWR VPWR _2292_/S sky130_fd_sc_hd__buf_8
XFILLER_20_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2060_ _2748_/Q _2826_/Q _2615_/B VGND VGND VPWR VPWR _2060_/X sky130_fd_sc_hd__mux2_1
XFILLER_19_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1913_ _2205_/A _2205_/D _1923_/B _2682_/Q _1698_/A VGND VGND VPWR VPWR _1913_/X
+ sky130_fd_sc_hd__o221a_1
X_2893_ _2893_/CLK _2893_/D VGND VGND VPWR VPWR _2893_/Q sky130_fd_sc_hd__dfxtp_1
X_1844_ _2722_/Q _1899_/B _1843_/X VGND VGND VPWR VPWR _1844_/X sky130_fd_sc_hd__o21a_1
XFILLER_8_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1775_ _2193_/B _1461_/A _1784_/C _1774_/X VGND VGND VPWR VPWR _1775_/X sky130_fd_sc_hd__a31o_1
XFILLER_57_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2258_ _2258_/A _2258_/B VGND VGND VPWR VPWR _2271_/B sky130_fd_sc_hd__nand2_1
X_2327_ _2820_/Q _2421_/B VGND VGND VPWR VPWR _2328_/A sky130_fd_sc_hd__and2_1
X_2189_ _2692_/Q VGND VGND VPWR VPWR _2189_/Y sky130_fd_sc_hd__inv_2
XFILLER_25_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1560_ _2627_/Q _1559_/X _1598_/S VGND VGND VPWR VPWR _2627_/D sky130_fd_sc_hd__mux2_1
X_1491_ _1473_/X _1491_/B _1491_/C _1491_/D VGND VGND VPWR VPWR _1492_/D sky130_fd_sc_hd__and4b_1
X_2112_ _2726_/Q input6/X _2121_/S VGND VGND VPWR VPWR _2726_/D sky130_fd_sc_hd__mux2_1
XTAP_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2043_ _2090_/A _1712_/B _1684_/B VGND VGND VPWR VPWR _2615_/B sky130_fd_sc_hd__a21o_2
XFILLER_22_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2876_ _2876_/CLK _2876_/D VGND VGND VPWR VPWR _2876_/Q sky130_fd_sc_hd__dfxtp_1
X_1827_ _2671_/Q _1826_/X _1982_/S VGND VGND VPWR VPWR _2671_/D sky130_fd_sc_hd__mux2_1
X_1689_ _2012_/A _2188_/C VGND VGND VPWR VPWR _2000_/B sky130_fd_sc_hd__nor2_1
X_1758_ _2660_/Q _1742_/B _1757_/X _1982_/S VGND VGND VPWR VPWR _2660_/D sky130_fd_sc_hd__a22o_1
XFILLER_57_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_2_1__f_i_clk clkbuf_0_i_clk/X VGND VGND VPWR VPWR clkbuf_2_1__f_i_clk/X sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_1_i_clk clkbuf_leaf_3_i_clk/A VGND VGND VPWR VPWR _2897_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_21_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2730_ _2730_/CLK _2730_/D VGND VGND VPWR VPWR _2730_/Q sky130_fd_sc_hd__dfxtp_2
X_2661_ _2876_/CLK _2661_/D VGND VGND VPWR VPWR _2661_/Q sky130_fd_sc_hd__dfxtp_1
X_1543_ _1630_/A _1708_/B VGND VGND VPWR VPWR _2090_/B sky130_fd_sc_hd__nor2_1
X_1612_ _1612_/A VGND VGND VPWR VPWR _1613_/B sky130_fd_sc_hd__inv_2
X_1474_ _2729_/Q _1474_/B VGND VGND VPWR VPWR _1475_/B sky130_fd_sc_hd__xor2_1
XFILLER_5_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2592_ _2892_/Q _2592_/B VGND VGND VPWR VPWR _2598_/B sky130_fd_sc_hd__or2_1
XFILLER_39_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2026_ _2697_/Q _2609_/B _1873_/X VGND VGND VPWR VPWR _2697_/D sky130_fd_sc_hd__a21o_1
XFILLER_40_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2859_ _2889_/CLK _2859_/D VGND VGND VPWR VPWR _2859_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_45_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput9 i_wb_addr[13] VGND VGND VPWR VPWR input9/X sky130_fd_sc_hd__clkbuf_2
XFILLER_36_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2644_ _2853_/CLK _2644_/D VGND VGND VPWR VPWR _2644_/Q sky130_fd_sc_hd__dfxtp_1
X_2713_ _2897_/CLK _2713_/D VGND VGND VPWR VPWR _2713_/Q sky130_fd_sc_hd__dfxtp_1
X_1526_ _1406_/A _1525_/X _2258_/A VGND VGND VPWR VPWR _1526_/Y sky130_fd_sc_hd__a21oi_1
X_1457_ _1457_/A _1457_/B VGND VGND VPWR VPWR _1465_/C sky130_fd_sc_hd__xnor2_1
X_2575_ _2888_/Q _2423_/X _2572_/X _2574_/X VGND VGND VPWR VPWR _2888_/D sky130_fd_sc_hd__o22a_1
X_1388_ _2776_/Q _1353_/Y _2262_/A _1387_/X VGND VGND VPWR VPWR _1388_/X sky130_fd_sc_hd__a211o_1
XFILLER_35_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2009_ _2009_/A _2009_/B VGND VGND VPWR VPWR _2148_/B sky130_fd_sc_hd__nand2_1
XPHY_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2291_ _2851_/Q _2304_/B _2295_/B _2821_/Q VGND VGND VPWR VPWR _2291_/X sky130_fd_sc_hd__a22o_1
X_2360_ _2571_/A _2810_/Q _2606_/B _2344_/X _2656_/Q VGND VGND VPWR VPWR _2360_/X
+ sky130_fd_sc_hd__a32o_1
X_1311_ _2857_/Q _1311_/B VGND VGND VPWR VPWR _2421_/B sky130_fd_sc_hd__nor2_2
XFILLER_64_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_14 _1680_/C VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_24_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_25 input52/X VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_36 input53/X VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2627_ _2828_/CLK _2627_/D VGND VGND VPWR VPWR _2627_/Q sky130_fd_sc_hd__dfxtp_1
X_1509_ _1509_/A _1509_/B VGND VGND VPWR VPWR _1509_/X sky130_fd_sc_hd__xor2_1
X_2558_ _2884_/Q _2881_/Q _2811_/Q VGND VGND VPWR VPWR _2558_/X sky130_fd_sc_hd__mux2_1
X_2489_ _2671_/Q _2419_/A _2588_/B _2488_/X _2437_/X VGND VGND VPWR VPWR _2489_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_62_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1860_ _2732_/Q _1763_/B _1859_/X _2012_/A VGND VGND VPWR VPWR _1860_/X sky130_fd_sc_hd__a211o_1
XFILLER_14_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput45 i_wb_data[26] VGND VGND VPWR VPWR input45/X sky130_fd_sc_hd__clkbuf_1
XFILLER_52_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput12 i_wb_addr[16] VGND VGND VPWR VPWR _1457_/A sky130_fd_sc_hd__clkbuf_2
Xinput56 i_wb_data[7] VGND VGND VPWR VPWR input56/X sky130_fd_sc_hd__clkbuf_1
Xinput34 i_wb_data[16] VGND VGND VPWR VPWR input34/X sky130_fd_sc_hd__clkbuf_1
Xinput23 i_wb_addr[8] VGND VGND VPWR VPWR _1471_/A sky130_fd_sc_hd__dlymetal6s2s_1
X_1791_ _2193_/B _1455_/A _1784_/C _1789_/X _1790_/X VGND VGND VPWR VPWR _1791_/X
+ sky130_fd_sc_hd__a32o_1
X_2274_ _2274_/A _2274_/B _2274_/C VGND VGND VPWR VPWR _2403_/S sky130_fd_sc_hd__nand3_4
XFILLER_42_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2343_ _2447_/B VGND VGND VPWR VPWR _2343_/X sky130_fd_sc_hd__buf_8
X_2412_ _2857_/Q _2412_/B VGND VGND VPWR VPWR _2412_/Y sky130_fd_sc_hd__nand2_1
XFILLER_52_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1989_ _1943_/S _1841_/Y _1986_/Y _1987_/X _2142_/A VGND VGND VPWR VPWR _1989_/X
+ sky130_fd_sc_hd__a311o_1
XFILLER_57_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1912_ _1934_/B VGND VGND VPWR VPWR _2205_/D sky130_fd_sc_hd__inv_2
X_1843_ _2730_/Q _1763_/B _1842_/X _2012_/A VGND VGND VPWR VPWR _1843_/X sky130_fd_sc_hd__a211o_1
X_2892_ _2893_/CLK _2892_/D VGND VGND VPWR VPWR _2892_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_6_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1774_ _2751_/Q _2013_/B _2012_/A _1765_/Y VGND VGND VPWR VPWR _1774_/X sky130_fd_sc_hd__a211o_1
XFILLER_57_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2257_ _1357_/X _2009_/A _2123_/A _1983_/A VGND VGND VPWR VPWR _2260_/C sky130_fd_sc_hd__o22a_1
X_2326_ _2820_/Q _2606_/B VGND VGND VPWR VPWR _2410_/A sky130_fd_sc_hd__nor2_2
X_2188_ _2188_/A _2188_/B _2188_/C _2188_/D VGND VGND VPWR VPWR _2188_/X sky130_fd_sc_hd__or4_1
XFILLER_25_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1490_ _1471_/Y _1472_/Y _1487_/X _1489_/Y VGND VGND VPWR VPWR _1491_/D sky130_fd_sc_hd__o211a_1
XTAP_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2042_ _2699_/Q _2609_/B _1841_/B _2041_/X VGND VGND VPWR VPWR _2699_/D sky130_fd_sc_hd__a22o_1
X_2111_ _2725_/Q _1509_/A _2121_/S VGND VGND VPWR VPWR _2725_/D sky130_fd_sc_hd__mux2_1
XTAP_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2875_ _2876_/CLK _2875_/D VGND VGND VPWR VPWR _2875_/Q sky130_fd_sc_hd__dfxtp_1
X_1826_ _2671_/Q _2402_/S _1740_/A _1823_/X _1825_/X VGND VGND VPWR VPWR _1826_/X
+ sky130_fd_sc_hd__a311o_1
X_1688_ _1988_/A _1688_/B VGND VGND VPWR VPWR _2188_/C sky130_fd_sc_hd__nor2_2
X_1757_ _2717_/Q _1763_/B _1756_/X VGND VGND VPWR VPWR _1757_/X sky130_fd_sc_hd__a21o_1
X_2309_ _2800_/Q _2292_/S _2305_/X _2833_/Q VGND VGND VPWR VPWR _2800_/D sky130_fd_sc_hd__a22o_1
XFILLER_53_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1611_ _1611_/A VGND VGND VPWR VPWR _2609_/B sky130_fd_sc_hd__buf_4
XFILLER_8_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2660_ _2883_/CLK _2660_/D VGND VGND VPWR VPWR _2660_/Q sky130_fd_sc_hd__dfxtp_1
X_1542_ _2402_/S _1539_/X _1541_/Y _2262_/B VGND VGND VPWR VPWR _1542_/X sky130_fd_sc_hd__a211o_1
X_1473_ _1471_/Y _1472_/Y _1458_/X _1784_/B VGND VGND VPWR VPWR _1473_/X sky130_fd_sc_hd__a22o_1
X_2591_ _2892_/Q _2592_/B VGND VGND VPWR VPWR _2593_/A sky130_fd_sc_hd__nand2_1
X_2025_ _2696_/Q _2609_/B _1865_/X VGND VGND VPWR VPWR _2696_/D sky130_fd_sc_hd__a21o_1
XFILLER_39_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2789_ _2828_/CLK _2789_/D VGND VGND VPWR VPWR _2789_/Q sky130_fd_sc_hd__dfxtp_1
X_2858_ _2889_/CLK _2858_/D VGND VGND VPWR VPWR _2858_/Q sky130_fd_sc_hd__dfxtp_1
X_1809_ _2726_/Q _1763_/B _1808_/X VGND VGND VPWR VPWR _1809_/X sky130_fd_sc_hd__a21o_1
XFILLER_6_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2643_ _2853_/CLK _2643_/D VGND VGND VPWR VPWR _2643_/Q sky130_fd_sc_hd__dfxtp_1
X_2574_ _2688_/Q _2447_/A _2588_/B _2573_/X _2437_/X VGND VGND VPWR VPWR _2574_/X
+ sky130_fd_sc_hd__a221o_1
X_2712_ _2816_/CLK _2712_/D VGND VGND VPWR VPWR _2712_/Q sky130_fd_sc_hd__dfxtp_1
X_1387_ _1383_/X _2205_/B _2259_/B _2776_/Q VGND VGND VPWR VPWR _1387_/X sky130_fd_sc_hd__and4b_1
X_1456_ _2732_/Q _1493_/C VGND VGND VPWR VPWR _1457_/B sky130_fd_sc_hd__xor2_1
X_1525_ _2122_/S _2202_/A _1519_/X _1524_/Y VGND VGND VPWR VPWR _1525_/X sky130_fd_sc_hd__a22o_1
Xclkbuf_leaf_0_i_clk clkbuf_leaf_3_i_clk/A VGND VGND VPWR VPWR _2816_/CLK sky130_fd_sc_hd__clkbuf_16
X_2008_ _2653_/Q _2821_/Q VGND VGND VPWR VPWR _2009_/A sky130_fd_sc_hd__or2_2
XFILLER_27_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2290_ _2289_/X _2786_/Q _2292_/S VGND VGND VPWR VPWR _2786_/D sky130_fd_sc_hd__mux2_1
XFILLER_49_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1310_ _2856_/Q _2855_/Q VGND VGND VPWR VPWR _1311_/B sky130_fd_sc_hd__or2_2
XFILLER_49_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_37 _1731_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_26 input53/X VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_15 _2606_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput100 _2796_/Q VGND VGND VPWR VPWR o_wb_data[7] sky130_fd_sc_hd__clkbuf_1
X_2626_ _2829_/CLK _2626_/D VGND VGND VPWR VPWR _2626_/Q sky130_fd_sc_hd__dfxtp_1
X_2557_ _2562_/A _2594_/B _2557_/C VGND VGND VPWR VPWR _2557_/X sky130_fd_sc_hd__and3_1
XFILLER_9_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1508_ _1508_/A _1508_/B VGND VGND VPWR VPWR _1509_/B sky130_fd_sc_hd__nand2_1
X_1439_ _2720_/Q _2721_/Q _1476_/C VGND VGND VPWR VPWR _1461_/B sky130_fd_sc_hd__nand3_2
X_2488_ _2670_/Q _2667_/Q _2561_/S VGND VGND VPWR VPWR _2488_/X sky130_fd_sc_hd__mux2_1
XFILLER_55_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput13 i_wb_addr[17] VGND VGND VPWR VPWR _1496_/A sky130_fd_sc_hd__clkbuf_2
X_1790_ _2666_/Q _1782_/Y _2205_/B VGND VGND VPWR VPWR _1790_/X sky130_fd_sc_hd__a21o_1
XFILLER_14_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput46 i_wb_data[27] VGND VGND VPWR VPWR input46/X sky130_fd_sc_hd__clkbuf_1
Xinput35 i_wb_data[17] VGND VGND VPWR VPWR input35/X sky130_fd_sc_hd__clkbuf_1
Xinput24 i_wb_addr[9] VGND VGND VPWR VPWR _1509_/A sky130_fd_sc_hd__dlymetal6s2s_1
X_2411_ _2820_/Q _2408_/X _2415_/D VGND VGND VPWR VPWR _2411_/Y sky130_fd_sc_hd__a21oi_1
XFILLER_6_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput57 i_wb_data[8] VGND VGND VPWR VPWR input57/X sky130_fd_sc_hd__clkbuf_1
X_2273_ _2819_/Q _2202_/B _2090_/Y _2272_/X _2259_/B VGND VGND VPWR VPWR _2274_/C
+ sky130_fd_sc_hd__o2111a_1
XFILLER_35_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2342_ _2606_/B _2415_/B VGND VGND VPWR VPWR _2447_/B sky130_fd_sc_hd__or2_4
X_1988_ _1988_/A _1988_/B _1988_/C VGND VGND VPWR VPWR _2142_/A sky130_fd_sc_hd__and3_1
X_2609_ _2609_/A _2609_/B _2609_/C VGND VGND VPWR VPWR _2610_/D sky130_fd_sc_hd__and3_1
XFILLER_57_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1842_ _2760_/Q _1943_/S _1837_/X _1840_/X _1841_/Y VGND VGND VPWR VPWR _1842_/X
+ sky130_fd_sc_hd__o221a_1
X_1911_ _2731_/Q _1899_/B _1900_/D _1910_/X VGND VGND VPWR VPWR _1911_/X sky130_fd_sc_hd__o22a_1
X_2891_ _2893_/CLK _2891_/D VGND VGND VPWR VPWR _2891_/Q sky130_fd_sc_hd__dfxtp_1
X_1773_ _2663_/Q _1742_/B _1772_/X _1982_/S VGND VGND VPWR VPWR _2663_/D sky130_fd_sc_hd__a22o_1
X_2187_ _1684_/B _2009_/A _2211_/A _2260_/B _2262_/C VGND VGND VPWR VPWR _2188_/D
+ sky130_fd_sc_hd__a2111o_1
X_2256_ _2609_/A _2256_/B VGND VGND VPWR VPWR _2256_/X sky130_fd_sc_hd__or2_1
X_2325_ _2325_/A VGND VGND VPWR VPWR _2606_/B sky130_fd_sc_hd__buf_4
XFILLER_40_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2041_ _2735_/Q _2028_/Y _2034_/X _2036_/Y _2040_/X VGND VGND VPWR VPWR _2041_/X
+ sky130_fd_sc_hd__o2111a_1
X_2110_ _2724_/Q _1471_/A _2121_/S VGND VGND VPWR VPWR _2724_/D sky130_fd_sc_hd__mux2_1
XFILLER_30_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1825_ _2671_/Q _1787_/A _1824_/X VGND VGND VPWR VPWR _1825_/X sky130_fd_sc_hd__a21o_1
X_2874_ _2876_/CLK _2874_/D VGND VGND VPWR VPWR _2874_/Q sky130_fd_sc_hd__dfxtp_1
X_1756_ _2747_/Q _2013_/B _1787_/A _2660_/Q _1755_/X VGND VGND VPWR VPWR _1756_/X
+ sky130_fd_sc_hd__a221o_1
X_2308_ _2799_/Q _2292_/S _2305_/X _2832_/Q VGND VGND VPWR VPWR _2799_/D sky130_fd_sc_hd__a22o_1
X_1687_ _1630_/A _2129_/D _1695_/B VGND VGND VPWR VPWR _1687_/X sky130_fd_sc_hd__o21ba_1
XFILLER_54_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2239_ _2759_/Q input33/X _2247_/S VGND VGND VPWR VPWR _2759_/D sky130_fd_sc_hd__mux2_1
XFILLER_21_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1610_ _1838_/A _1736_/B VGND VGND VPWR VPWR _1611_/A sky130_fd_sc_hd__or2_1
X_2590_ _2587_/Y _2588_/Y _2589_/Y _2600_/S _2891_/Q VGND VGND VPWR VPWR _2891_/D
+ sky130_fd_sc_hd__a32o_1
XFILLER_12_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1541_ _2270_/A _1678_/D VGND VGND VPWR VPWR _1541_/Y sky130_fd_sc_hd__nor2_1
X_1472_ _2724_/Q _1472_/B VGND VGND VPWR VPWR _1472_/Y sky130_fd_sc_hd__xnor2_1
X_2024_ _2695_/Q _2609_/B _1857_/X VGND VGND VPWR VPWR _2695_/D sky130_fd_sc_hd__a21o_1
XFILLER_47_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2857_ _2857_/CLK _2857_/D VGND VGND VPWR VPWR _2857_/Q sky130_fd_sc_hd__dfxtp_2
XFILLER_10_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2788_ _2850_/CLK _2788_/D VGND VGND VPWR VPWR _2788_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_40_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1739_ _1709_/X _2610_/A _1723_/Y _1738_/X VGND VGND VPWR VPWR _1926_/B sky130_fd_sc_hd__o211ai_4
X_1808_ _2748_/Q _2123_/B _1807_/X VGND VGND VPWR VPWR _1808_/X sky130_fd_sc_hd__a21o_1
XFILLER_38_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2711_ _2816_/CLK _2711_/D VGND VGND VPWR VPWR _2711_/Q sky130_fd_sc_hd__dfxtp_1
X_2642_ _2853_/CLK _2642_/D VGND VGND VPWR VPWR _2642_/Q sky130_fd_sc_hd__dfxtp_1
X_1524_ _2653_/Q _2013_/B _2123_/A _2162_/B VGND VGND VPWR VPWR _1524_/Y sky130_fd_sc_hd__nor4_1
X_2573_ _2687_/Q _2684_/Q _2655_/Q VGND VGND VPWR VPWR _2573_/X sky130_fd_sc_hd__mux2_1
X_1386_ _2186_/A _1386_/B VGND VGND VPWR VPWR _2259_/B sky130_fd_sc_hd__nand2_1
X_1455_ _1455_/A _1455_/B VGND VGND VPWR VPWR _1465_/B sky130_fd_sc_hd__xnor2_1
X_2007_ _2691_/Q _2822_/Q _2819_/Q VGND VGND VPWR VPWR _2007_/X sky130_fd_sc_hd__mux2_1
XFILLER_35_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_16 _2410_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_27 input56/X VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput101 _2797_/Q VGND VGND VPWR VPWR o_wb_data[8] sky130_fd_sc_hd__clkbuf_1
X_2625_ _2829_/CLK _2625_/D VGND VGND VPWR VPWR _2625_/Q sky130_fd_sc_hd__dfxtp_1
X_1507_ _2724_/Q _1476_/C _1476_/D _2725_/Q VGND VGND VPWR VPWR _1508_/B sky130_fd_sc_hd__a31o_1
X_2487_ _2606_/A _2867_/Q _2343_/X _2486_/X VGND VGND VPWR VPWR _2487_/X sky130_fd_sc_hd__o211a_1
X_2556_ _2684_/Q _2681_/Q _2561_/S VGND VGND VPWR VPWR _2557_/C sky130_fd_sc_hd__mux2_1
X_1369_ _2653_/Q _1357_/X _2001_/D _1366_/Y _1943_/S VGND VGND VPWR VPWR _1369_/X
+ sky130_fd_sc_hd__o221a_1
X_1438_ _1438_/A VGND VGND VPWR VPWR _1476_/C sky130_fd_sc_hd__buf_2
XFILLER_23_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput25 i_wb_ctrl_stb VGND VGND VPWR VPWR _2193_/A sky130_fd_sc_hd__clkbuf_4
Xinput36 i_wb_data[18] VGND VGND VPWR VPWR input36/X sky130_fd_sc_hd__clkbuf_1
Xinput14 i_wb_addr[18] VGND VGND VPWR VPWR _1505_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_14_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput47 i_wb_data[28] VGND VGND VPWR VPWR input47/X sky130_fd_sc_hd__clkbuf_1
Xinput58 i_wb_data[9] VGND VGND VPWR VPWR input58/X sky130_fd_sc_hd__clkbuf_1
X_2341_ _2341_/A VGND VGND VPWR VPWR _2341_/Y sky130_fd_sc_hd__inv_2
X_2410_ _2410_/A _2410_/B VGND VGND VPWR VPWR _2415_/D sky130_fd_sc_hd__or2_1
XFILLER_6_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2272_ _2272_/A _2272_/B _2272_/C VGND VGND VPWR VPWR _2272_/X sky130_fd_sc_hd__and3_1
XFILLER_37_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1987_ _1782_/A _2737_/Q _2736_/Q _1841_/A _1932_/B VGND VGND VPWR VPWR _1987_/X
+ sky130_fd_sc_hd__o311a_1
X_2608_ _2562_/A _2601_/Y _2605_/X _2607_/Y _2895_/Q VGND VGND VPWR VPWR _2895_/D
+ sky130_fd_sc_hd__a32o_1
X_2539_ _2681_/Q _2419_/A _2343_/X _2538_/X _2437_/X VGND VGND VPWR VPWR _2539_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_28_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1910_ _1645_/Y _1908_/X _1932_/B _1897_/A VGND VGND VPWR VPWR _1910_/X sky130_fd_sc_hd__o22a_1
X_2890_ _2895_/CLK _2890_/D VGND VGND VPWR VPWR _2890_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_19_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1841_ _1841_/A _1841_/B VGND VGND VPWR VPWR _1841_/Y sky130_fd_sc_hd__nor2_2
X_1772_ _2720_/Q _1763_/B _1771_/X VGND VGND VPWR VPWR _1772_/X sky130_fd_sc_hd__a21o_1
XFILLER_8_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2324_ _2857_/Q _2415_/A VGND VGND VPWR VPWR _2325_/A sky130_fd_sc_hd__and2b_1
X_2186_ _2186_/A _2186_/B VGND VGND VPWR VPWR _2262_/C sky130_fd_sc_hd__and2_1
X_2255_ _2775_/Q _1731_/A _2255_/S VGND VGND VPWR VPWR _2775_/D sky130_fd_sc_hd__mux2_1
XFILLER_25_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2040_ _2733_/Q _2031_/Y _2698_/Q _1503_/Y _2039_/X VGND VGND VPWR VPWR _2040_/X
+ sky130_fd_sc_hd__o221a_1
XFILLER_47_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2873_ _2877_/CLK _2873_/D VGND VGND VPWR VPWR _2873_/Q sky130_fd_sc_hd__dfxtp_1
X_1686_ _1686_/A _1686_/B _1738_/B VGND VGND VPWR VPWR _1695_/B sky130_fd_sc_hd__or3b_1
X_1755_ _2193_/B _1963_/A _1784_/C VGND VGND VPWR VPWR _1755_/X sky130_fd_sc_hd__and3_1
X_1824_ _2193_/B input8/X _1784_/C _1765_/Y _1770_/B VGND VGND VPWR VPWR _1824_/X
+ sky130_fd_sc_hd__a32o_1
X_2307_ _2798_/Q _2292_/S _2305_/X _2831_/Q VGND VGND VPWR VPWR _2798_/D sky130_fd_sc_hd__a22o_1
XFILLER_57_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2238_ _2758_/Q input32/X _2247_/S VGND VGND VPWR VPWR _2758_/D sky130_fd_sc_hd__mux2_1
XFILLER_53_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2169_ _1941_/B _2168_/X _1648_/Y VGND VGND VPWR VPWR _2169_/Y sky130_fd_sc_hd__a21boi_1
XFILLER_56_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1540_ _2193_/A _2264_/A VGND VGND VPWR VPWR _1678_/D sky130_fd_sc_hd__nor2_2
XFILLER_5_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1471_ _1471_/A VGND VGND VPWR VPWR _1471_/Y sky130_fd_sc_hd__inv_2
XFILLER_10_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2023_ _2694_/Q _2609_/B _1849_/X VGND VGND VPWR VPWR _2694_/D sky130_fd_sc_hd__a21o_1
XFILLER_35_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1807_ _2756_/Q _2013_/B _2012_/A _2718_/Q VGND VGND VPWR VPWR _1807_/X sky130_fd_sc_hd__a22o_1
X_2856_ _2857_/CLK _2856_/D VGND VGND VPWR VPWR _2856_/Q sky130_fd_sc_hd__dfxtp_2
X_2787_ _2850_/CLK _2787_/D VGND VGND VPWR VPWR _2787_/Q sky130_fd_sc_hd__dfxtp_1
X_1738_ _1738_/A _1738_/B _1984_/C VGND VGND VPWR VPWR _1738_/X sky130_fd_sc_hd__and3_1
X_1669_ _2714_/Q _2713_/Q _2083_/A VGND VGND VPWR VPWR _1669_/X sky130_fd_sc_hd__or3_1
XTAP_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2710_ _2748_/CLK _2710_/D VGND VGND VPWR VPWR _2710_/Q sky130_fd_sc_hd__dfxtp_1
X_2641_ _2844_/CLK _2641_/D VGND VGND VPWR VPWR _2641_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_58_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1523_ _1639_/A _1736_/B VGND VGND VPWR VPWR _2162_/B sky130_fd_sc_hd__nor2_2
X_2572_ _2606_/A _2884_/Q _2343_/X _2571_/X VGND VGND VPWR VPWR _2572_/X sky130_fd_sc_hd__o211a_1
X_1454_ _1472_/B _1454_/B VGND VGND VPWR VPWR _1455_/B sky130_fd_sc_hd__and2_1
X_1385_ _1418_/A _2688_/Q VGND VGND VPWR VPWR _1386_/B sky130_fd_sc_hd__or2_1
XFILLER_27_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2006_ _2690_/Q _2005_/X _2006_/S VGND VGND VPWR VPWR _2690_/D sky130_fd_sc_hd__mux2_1
X_2839_ _2844_/CLK _2839_/D VGND VGND VPWR VPWR _2839_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_58_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2624_ _2829_/CLK _2624_/D VGND VGND VPWR VPWR _2624_/Q sky130_fd_sc_hd__dfxtp_1
XANTENNA_17 _2512_/C VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_28 _2727_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput102 _2798_/Q VGND VGND VPWR VPWR o_wb_data[9] sky130_fd_sc_hd__clkbuf_1
X_1506_ _1505_/B _1505_/C _1505_/A VGND VGND VPWR VPWR _1506_/Y sky130_fd_sc_hd__a21oi_1
X_1437_ _2716_/Q _2717_/Q _2718_/Q _2719_/Q VGND VGND VPWR VPWR _1438_/A sky130_fd_sc_hd__and4_1
X_2486_ _2571_/A _2870_/Q VGND VGND VPWR VPWR _2486_/X sky130_fd_sc_hd__or2_1
X_2555_ _2884_/Q _2423_/X _2552_/X _2554_/X VGND VGND VPWR VPWR _2884_/D sky130_fd_sc_hd__o22a_1
XFILLER_46_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1368_ _1988_/A _1908_/C VGND VGND VPWR VPWR _1943_/S sky130_fd_sc_hd__nand2_8
XFILLER_11_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput26 i_wb_cyc VGND VGND VPWR VPWR _2261_/B sky130_fd_sc_hd__buf_2
Xinput15 i_wb_addr[19] VGND VGND VPWR VPWR _1448_/A sky130_fd_sc_hd__clkbuf_2
Xinput59 i_wb_data_stb VGND VGND VPWR VPWR _1327_/A sky130_fd_sc_hd__clkbuf_1
XFILLER_52_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput48 i_wb_data[29] VGND VGND VPWR VPWR input48/X sky130_fd_sc_hd__clkbuf_1
Xinput37 i_wb_data[19] VGND VGND VPWR VPWR input37/X sky130_fd_sc_hd__clkbuf_1
XFILLER_6_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2271_ _1784_/C _2271_/B _2271_/C VGND VGND VPWR VPWR _2274_/B sky130_fd_sc_hd__and3b_1
X_2340_ _2812_/Q _2341_/A _2339_/X _2346_/A VGND VGND VPWR VPWR _2812_/D sky130_fd_sc_hd__o22a_1
XFILLER_37_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1986_ _2027_/S _2614_/B VGND VGND VPWR VPWR _1986_/Y sky130_fd_sc_hd__nor2_1
X_2607_ _2594_/B _2406_/Y _2606_/Y _2601_/Y VGND VGND VPWR VPWR _2607_/Y sky130_fd_sc_hd__o31ai_1
XFILLER_28_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2469_ _2667_/Q _2419_/A _2343_/X _2468_/X _2437_/X VGND VGND VPWR VPWR _2469_/X
+ sky130_fd_sc_hd__a221o_1
X_2538_ _2880_/Q _2877_/Q _2811_/Q VGND VGND VPWR VPWR _2538_/X sky130_fd_sc_hd__mux2_1
XFILLER_43_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1840_ _2700_/Q _2123_/B _2614_/B _2744_/Q _2013_/B VGND VGND VPWR VPWR _1840_/X
+ sky130_fd_sc_hd__a221o_1
X_1771_ _2750_/Q _2013_/B _1787_/A _2663_/Q _1770_/X VGND VGND VPWR VPWR _1771_/X
+ sky130_fd_sc_hd__a221o_1
X_2254_ _2774_/Q input50/X _2255_/S VGND VGND VPWR VPWR _2774_/D sky130_fd_sc_hd__mux2_1
X_2323_ _2856_/Q _2323_/B VGND VGND VPWR VPWR _2415_/A sky130_fd_sc_hd__nor2_1
XFILLER_40_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2185_ _2180_/X _2184_/X _1987_/X VGND VGND VPWR VPWR _2185_/Y sky130_fd_sc_hd__a21oi_1
XFILLER_25_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1969_ _1841_/A _1968_/X _1956_/Y VGND VGND VPWR VPWR _1969_/X sky130_fd_sc_hd__o21a_1
XFILLER_0_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1823_ _2728_/Q _1763_/B _1822_/X VGND VGND VPWR VPWR _1823_/X sky130_fd_sc_hd__a21o_1
X_2872_ _2877_/CLK _2872_/D VGND VGND VPWR VPWR _2872_/Q sky130_fd_sc_hd__dfxtp_1
X_1685_ _1685_/A _1984_/A _2202_/B VGND VGND VPWR VPWR _1738_/B sky130_fd_sc_hd__and3_1
X_1754_ _1754_/A VGND VGND VPWR VPWR _1763_/B sky130_fd_sc_hd__buf_4
X_2306_ _2797_/Q _2292_/S _2305_/X _2830_/Q VGND VGND VPWR VPWR _2797_/D sky130_fd_sc_hd__a22o_1
X_2237_ _2757_/Q input31/X _2247_/S VGND VGND VPWR VPWR _2757_/D sky130_fd_sc_hd__mux2_1
XFILLER_53_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2099_ _2097_/X _2130_/B _2099_/C _2270_/B VGND VGND VPWR VPWR _2100_/C sky130_fd_sc_hd__and4b_1
X_2168_ _1782_/A _2737_/Q _2018_/C _1536_/X VGND VGND VPWR VPWR _2168_/X sky130_fd_sc_hd__a31o_1
XFILLER_13_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1470_ _1470_/A _1470_/B VGND VGND VPWR VPWR _1492_/C sky130_fd_sc_hd__xor2_1
XFILLER_5_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2022_ _2693_/Q _2609_/B _1837_/X VGND VGND VPWR VPWR _2693_/D sky130_fd_sc_hd__a21o_1
X_2786_ _2850_/CLK _2786_/D VGND VGND VPWR VPWR _2786_/Q sky130_fd_sc_hd__dfxtp_1
X_1806_ _2668_/Q _1805_/X _1982_/S VGND VGND VPWR VPWR _2668_/D sky130_fd_sc_hd__mux2_1
X_2855_ _2857_/CLK _2855_/D VGND VGND VPWR VPWR _2855_/Q sky130_fd_sc_hd__dfxtp_2
XTAP_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1599_ _2646_/Q _2643_/Q _2818_/Q VGND VGND VPWR VPWR _1599_/X sky130_fd_sc_hd__mux2_1
XFILLER_49_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1737_ _2402_/S _2256_/B _1735_/X _1736_/X VGND VGND VPWR VPWR _1984_/C sky130_fd_sc_hd__o211a_1
X_1668_ _2710_/Q _2709_/Q _2706_/Q _1668_/D VGND VGND VPWR VPWR _2083_/A sky130_fd_sc_hd__or4_1
XFILLER_45_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2640_ _2853_/CLK _2640_/D VGND VGND VPWR VPWR _2640_/Q sky130_fd_sc_hd__dfxtp_1
X_1522_ _1841_/A _2122_/S _1712_/B VGND VGND VPWR VPWR _2123_/A sky130_fd_sc_hd__or3_1
X_1453_ _2720_/Q _2721_/Q _2722_/Q _1476_/C _2723_/Q VGND VGND VPWR VPWR _1454_/B
+ sky130_fd_sc_hd__a41o_1
X_2571_ _2571_/A _2887_/Q VGND VGND VPWR VPWR _2571_/X sky130_fd_sc_hd__or2_1
X_1384_ _1630_/A _2000_/A VGND VGND VPWR VPWR _2186_/A sky130_fd_sc_hd__nor2_1
XFILLER_27_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2005_ _1784_/C _1999_/Y _2004_/X _2262_/A VGND VGND VPWR VPWR _2005_/X sky130_fd_sc_hd__a211o_1
XFILLER_50_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_196 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2838_ _2838_/CLK _2838_/D VGND VGND VPWR VPWR _2838_/Q sky130_fd_sc_hd__dfxtp_1
X_2769_ _2775_/CLK _2769_/D VGND VGND VPWR VPWR _2769_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_58_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_188 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_29 _2728_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_18 _2587_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2623_ _2829_/CLK _2623_/D VGND VGND VPWR VPWR _2623_/Q sky130_fd_sc_hd__dfxtp_1
Xoutput103 _2620_/Q VGND VGND VPWR VPWR o_wb_stall sky130_fd_sc_hd__clkbuf_1
X_2554_ _2684_/Q _2419_/A _2588_/B _2553_/X _2437_/X VGND VGND VPWR VPWR _2554_/X
+ sky130_fd_sc_hd__a221o_1
X_1436_ _2261_/B _2127_/A VGND VGND VPWR VPWR _2209_/A sky130_fd_sc_hd__and2_2
X_1505_ _1505_/A _1505_/B _1505_/C VGND VGND VPWR VPWR _1505_/X sky130_fd_sc_hd__and3_1
X_2485_ _2870_/Q _2423_/X _2482_/X _2484_/X VGND VGND VPWR VPWR _2870_/D sky130_fd_sc_hd__o22a_1
X_1367_ _1835_/A _1690_/A VGND VGND VPWR VPWR _1908_/C sky130_fd_sc_hd__nor2_4
XFILLER_55_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput49 i_wb_data[2] VGND VGND VPWR VPWR input49/X sky130_fd_sc_hd__clkbuf_1
Xinput38 i_wb_data[1] VGND VGND VPWR VPWR input38/X sky130_fd_sc_hd__clkbuf_1
Xinput16 i_wb_addr[1] VGND VGND VPWR VPWR _1963_/A sky130_fd_sc_hd__clkbuf_4
XFILLER_6_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput27 i_wb_data[0] VGND VGND VPWR VPWR input27/X sky130_fd_sc_hd__clkbuf_1
X_2270_ _2270_/A _2270_/B _2270_/C VGND VGND VPWR VPWR _2271_/C sky130_fd_sc_hd__and3_1
XFILLER_52_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1985_ _1709_/X _1983_/X _1984_/X _1723_/Y VGND VGND VPWR VPWR _2006_/S sky130_fd_sc_hd__o211a_1
X_2537_ _2562_/A _2594_/B _2537_/C VGND VGND VPWR VPWR _2537_/X sky130_fd_sc_hd__and3_1
XFILLER_9_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2606_ _2606_/A _2606_/B VGND VGND VPWR VPWR _2606_/Y sky130_fd_sc_hd__nor2_1
X_2399_ _2651_/Q _2648_/Q _2399_/S VGND VGND VPWR VPWR _2399_/X sky130_fd_sc_hd__mux2_1
X_1419_ _2259_/A _1419_/B VGND VGND VPWR VPWR _1419_/Y sky130_fd_sc_hd__nand2_1
X_2468_ _2866_/Q _2863_/Q _2571_/A VGND VGND VPWR VPWR _2468_/X sky130_fd_sc_hd__mux2_1
XFILLER_43_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1770_ _2193_/B _1770_/B _1784_/C VGND VGND VPWR VPWR _1770_/X sky130_fd_sc_hd__and3_1
XFILLER_8_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2253_ _2773_/Q input48/X _2255_/S VGND VGND VPWR VPWR _2773_/D sky130_fd_sc_hd__mux2_1
XFILLER_33_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2184_ _2181_/X _2183_/X _2126_/B VGND VGND VPWR VPWR _2184_/X sky130_fd_sc_hd__o21a_1
X_2322_ _2856_/Q _2855_/Q VGND VGND VPWR VPWR _2412_/B sky130_fd_sc_hd__nand2_1
X_1899_ _2272_/B _1899_/B VGND VGND VPWR VPWR _1900_/D sky130_fd_sc_hd__nand2_1
X_1968_ _2774_/Q _1943_/S _1930_/Y VGND VGND VPWR VPWR _1968_/X sky130_fd_sc_hd__o21a_1
XFILLER_48_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1753_ _1753_/A _1841_/B VGND VGND VPWR VPWR _1754_/A sky130_fd_sc_hd__or2_1
X_1822_ _2750_/Q _2123_/B _1821_/X VGND VGND VPWR VPWR _1822_/X sky130_fd_sc_hd__a21o_1
X_2871_ _2877_/CLK _2871_/D VGND VGND VPWR VPWR _2871_/Q sky130_fd_sc_hd__dfxtp_1
X_1684_ _2122_/S _1684_/B VGND VGND VPWR VPWR _2202_/B sky130_fd_sc_hd__nor2_4
X_2305_ _2305_/A VGND VGND VPWR VPWR _2305_/X sky130_fd_sc_hd__clkbuf_4
X_2167_ _1676_/A _1984_/A _2166_/X _1535_/Y _2655_/Q VGND VGND VPWR VPWR _2167_/X
+ sky130_fd_sc_hd__a32o_1
XFILLER_38_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2236_ _2756_/Q input30/X _2247_/S VGND VGND VPWR VPWR _2756_/D sky130_fd_sc_hd__mux2_1
X_2098_ _2098_/A _2125_/A _1736_/X VGND VGND VPWR VPWR _2130_/B sky130_fd_sc_hd__or3b_1
XFILLER_21_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2021_ _2692_/Q _2017_/Y _2021_/S VGND VGND VPWR VPWR _2692_/D sky130_fd_sc_hd__mux2_1
XFILLER_39_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2785_ _2850_/CLK _2785_/D VGND VGND VPWR VPWR _2785_/Q sky130_fd_sc_hd__dfxtp_1
X_2854_ _2854_/CLK _2854_/D VGND VGND VPWR VPWR _2854_/Q sky130_fd_sc_hd__dfxtp_1
X_1736_ _2742_/Q _1736_/B VGND VGND VPWR VPWR _1736_/X sky130_fd_sc_hd__or2_1
X_1805_ _2668_/Q _2402_/S _1740_/A _1802_/X _1804_/X VGND VGND VPWR VPWR _1805_/X
+ sky130_fd_sc_hd__a311o_1
X_1598_ _2646_/Q _1597_/X _1598_/S VGND VGND VPWR VPWR _2646_/D sky130_fd_sc_hd__mux2_1
XTAP_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1667_ _2712_/Q _2711_/Q _2708_/Q _2707_/Q VGND VGND VPWR VPWR _1668_/D sky130_fd_sc_hd__or4_1
XFILLER_53_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2219_ _2189_/Y _1897_/B _1934_/B _2168_/X VGND VGND VPWR VPWR _2219_/X sky130_fd_sc_hd__a22o_1
XFILLER_41_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2570_ _2887_/Q _2423_/X _2567_/X _2569_/X VGND VGND VPWR VPWR _2887_/D sky130_fd_sc_hd__o22a_1
X_1383_ _1372_/X _2046_/A _1676_/A _2148_/A VGND VGND VPWR VPWR _1383_/X sky130_fd_sc_hd__o211a_1
X_1452_ _1476_/C _1476_/D VGND VGND VPWR VPWR _1472_/B sky130_fd_sc_hd__nand2_1
XFILLER_4_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1521_ _1521_/A VGND VGND VPWR VPWR _2013_/B sky130_fd_sc_hd__clkbuf_16
XFILLER_35_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2004_ _2000_/Y _1990_/B _2002_/X _2003_/X VGND VGND VPWR VPWR _2004_/X sky130_fd_sc_hd__o31a_1
XFILLER_31_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2837_ _2837_/CLK _2837_/D VGND VGND VPWR VPWR _2837_/Q sky130_fd_sc_hd__dfxtp_1
X_2699_ _2854_/CLK _2699_/D VGND VGND VPWR VPWR _2699_/Q sky130_fd_sc_hd__dfxtp_1
X_2768_ _2775_/CLK _2768_/D VGND VGND VPWR VPWR _2768_/Q sky130_fd_sc_hd__dfxtp_1
X_1719_ _1934_/B _2018_/D VGND VGND VPWR VPWR _1719_/Y sky130_fd_sc_hd__nor2_1
XTAP_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_156 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_19 _2087_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2622_ _2824_/CLK _2622_/D VGND VGND VPWR VPWR _2622_/Q sky130_fd_sc_hd__dfxtp_1
X_1504_ _2732_/Q _2733_/Q _1493_/C _2734_/Q VGND VGND VPWR VPWR _1505_/C sky130_fd_sc_hd__a31o_1
X_2553_ _2683_/Q _2680_/Q _2655_/Q VGND VGND VPWR VPWR _2553_/X sky130_fd_sc_hd__mux2_1
X_1435_ _1690_/A _1736_/B VGND VGND VPWR VPWR _2127_/A sky130_fd_sc_hd__nor2_2
X_1366_ _2001_/C _1753_/A VGND VGND VPWR VPWR _1366_/Y sky130_fd_sc_hd__nand2_1
X_2484_ _2670_/Q _2419_/A _2343_/X _2483_/X _2437_/X VGND VGND VPWR VPWR _2484_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_23_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput39 i_wb_data[20] VGND VGND VPWR VPWR input39/X sky130_fd_sc_hd__clkbuf_1
Xinput28 i_wb_data[10] VGND VGND VPWR VPWR input28/X sky130_fd_sc_hd__clkbuf_1
XFILLER_6_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput17 i_wb_addr[2] VGND VGND VPWR VPWR _1759_/B sky130_fd_sc_hd__clkbuf_2
XFILLER_60_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1984_ _1984_/A _2202_/B _1984_/C VGND VGND VPWR VPWR _1984_/X sky130_fd_sc_hd__and3_1
XFILLER_20_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2467_ _2562_/A _2594_/B _2467_/C VGND VGND VPWR VPWR _2467_/X sky130_fd_sc_hd__and3_1
X_2605_ _2577_/Y _2578_/Y _2424_/Y _2425_/Y VGND VGND VPWR VPWR _2605_/X sky130_fd_sc_hd__a31o_1
X_2536_ _2680_/Q _2677_/Q _2561_/S VGND VGND VPWR VPWR _2537_/C sky130_fd_sc_hd__mux2_1
XFILLER_57_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1418_ _1418_/A _1684_/B VGND VGND VPWR VPWR _2259_/A sky130_fd_sc_hd__nand2_1
X_1349_ _1349_/A VGND VGND VPWR VPWR _2272_/A sky130_fd_sc_hd__buf_4
X_2398_ _2852_/Q _1607_/X _2400_/S VGND VGND VPWR VPWR _2852_/D sky130_fd_sc_hd__mux2_1
XFILLER_28_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2321_ _2571_/A _2561_/S _2321_/S VGND VGND VPWR VPWR _2811_/D sky130_fd_sc_hd__mux2_1
X_2252_ _2772_/Q input47/X _2255_/S VGND VGND VPWR VPWR _2772_/D sky130_fd_sc_hd__mux2_1
XFILLER_26_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2183_ _2749_/Q _2750_/Q _2182_/Y _2614_/B VGND VGND VPWR VPWR _2183_/X sky130_fd_sc_hd__o31a_1
X_1898_ _2768_/Q _2009_/B _1943_/S VGND VGND VPWR VPWR _1900_/C sky130_fd_sc_hd__mux2_1
X_1967_ _2193_/B _2736_/Q VGND VGND VPWR VPWR _1999_/A sky130_fd_sc_hd__and2_1
X_2519_ _2677_/Q _2419_/A _2343_/X _2518_/X _2437_/X VGND VGND VPWR VPWR _2519_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_56_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2870_ _2877_/CLK _2870_/D VGND VGND VPWR VPWR _2870_/Q sky130_fd_sc_hd__dfxtp_1
X_1683_ _2013_/B _1713_/B _2172_/A _1683_/D VGND VGND VPWR VPWR _1686_/A sky130_fd_sc_hd__or4_1
XFILLER_30_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1821_ _2758_/Q _2013_/B _2012_/A _2720_/Q VGND VGND VPWR VPWR _1821_/X sky130_fd_sc_hd__a22o_1
X_1752_ _2659_/Q _1982_/S _1751_/X VGND VGND VPWR VPWR _2659_/D sky130_fd_sc_hd__o21a_1
X_2304_ _2403_/S _2304_/B VGND VGND VPWR VPWR _2305_/A sky130_fd_sc_hd__and2b_1
XFILLER_57_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2166_ _2157_/Y _2202_/B _2164_/X _2165_/Y VGND VGND VPWR VPWR _2166_/X sky130_fd_sc_hd__a31o_1
X_2097_ _2258_/A _2188_/B _2097_/C VGND VGND VPWR VPWR _2097_/X sky130_fd_sc_hd__or3_1
XFILLER_0_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2235_ _2755_/Q input29/X _2247_/S VGND VGND VPWR VPWR _2755_/D sky130_fd_sc_hd__mux2_1
XFILLER_21_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2020_ _1708_/X _2018_/X _2019_/X VGND VGND VPWR VPWR _2021_/S sky130_fd_sc_hd__a21oi_1
XFILLER_35_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2853_ _2853_/CLK _2853_/D VGND VGND VPWR VPWR _2853_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_50_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2784_ _2844_/CLK _2784_/D VGND VGND VPWR VPWR _2784_/Q sky130_fd_sc_hd__dfxtp_1
X_1735_ _1729_/X _2609_/C _1735_/C VGND VGND VPWR VPWR _1735_/X sky130_fd_sc_hd__and3b_1
X_1666_ _2262_/B _1665_/Y _2172_/A _1541_/Y VGND VGND VPWR VPWR _1666_/X sky130_fd_sc_hd__a211o_1
X_1804_ _2668_/Q _1787_/A _1803_/X VGND VGND VPWR VPWR _1804_/X sky130_fd_sc_hd__a21o_1
X_1597_ _2645_/Q _2642_/Q _2818_/Q VGND VGND VPWR VPWR _1597_/X sky130_fd_sc_hd__mux2_1
XTAP_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2149_ _2653_/Q _2609_/A _2209_/A _1721_/Y VGND VGND VPWR VPWR _2150_/D sky130_fd_sc_hd__a31o_1
XFILLER_38_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2218_ _2691_/Q _1765_/B _1928_/A VGND VGND VPWR VPWR _2218_/X sky130_fd_sc_hd__o21a_1
XFILLER_14_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1520_ _1988_/A _1908_/C VGND VGND VPWR VPWR _1521_/A sky130_fd_sc_hd__and2_1
X_1382_ _1685_/A _2258_/B VGND VGND VPWR VPWR _2148_/A sky130_fd_sc_hd__or2_1
X_1451_ input8/X _1451_/B VGND VGND VPWR VPWR _1465_/A sky130_fd_sc_hd__xnor2_1
XFILLER_4_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2003_ _1706_/A _2690_/Q _1706_/B _2205_/B VGND VGND VPWR VPWR _2003_/X sky130_fd_sc_hd__a31o_1
X_2836_ _2836_/CLK _2836_/D VGND VGND VPWR VPWR _2836_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_50_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1718_ _1782_/A _2737_/Q VGND VGND VPWR VPWR _2018_/D sky130_fd_sc_hd__nand2_1
X_2767_ _2775_/CLK _2767_/D VGND VGND VPWR VPWR _2767_/Q sky130_fd_sc_hd__dfxtp_1
X_2698_ _2775_/CLK _2698_/D VGND VGND VPWR VPWR _2698_/Q sky130_fd_sc_hd__dfxtp_2
X_1649_ _1988_/C _1648_/Y _1841_/A VGND VGND VPWR VPWR _1738_/A sky130_fd_sc_hd__o21ai_1
XTAP_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1503_ _2735_/Q VGND VGND VPWR VPWR _1503_/Y sky130_fd_sc_hd__inv_2
XFILLER_56_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2621_ _2836_/CLK _2621_/D VGND VGND VPWR VPWR _2621_/Q sky130_fd_sc_hd__dfxtp_1
X_2483_ _2869_/Q _2866_/Q _2571_/A VGND VGND VPWR VPWR _2483_/X sky130_fd_sc_hd__mux2_1
X_2552_ _2606_/A _2880_/Q _2343_/X _2551_/X VGND VGND VPWR VPWR _2552_/X sky130_fd_sc_hd__o211a_1
XFILLER_55_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1434_ _1988_/A _1630_/A _2090_/A VGND VGND VPWR VPWR _1736_/B sky130_fd_sc_hd__nand3_4
X_1365_ _1897_/A _1748_/B VGND VGND VPWR VPWR _1753_/A sky130_fd_sc_hd__nor2_1
XFILLER_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2819_ _2824_/CLK _2819_/D VGND VGND VPWR VPWR _2819_/Q sky130_fd_sc_hd__dfxtp_4
XFILLER_11_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput18 i_wb_addr[3] VGND VGND VPWR VPWR _1489_/A sky130_fd_sc_hd__clkbuf_2
Xinput29 i_wb_data[11] VGND VGND VPWR VPWR input29/X sky130_fd_sc_hd__clkbuf_1
XFILLER_10_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1983_ _1983_/A _1983_/B VGND VGND VPWR VPWR _1983_/X sky130_fd_sc_hd__or2_1
X_2604_ _2562_/A _2601_/Y _2602_/X _2603_/Y _2894_/Q VGND VGND VPWR VPWR _2894_/D
+ sky130_fd_sc_hd__a32o_1
XFILLER_9_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1417_ _1988_/A _1612_/A VGND VGND VPWR VPWR _1684_/B sky130_fd_sc_hd__nor2_4
X_2466_ _2666_/Q _2663_/Q _2561_/S VGND VGND VPWR VPWR _2467_/C sky130_fd_sc_hd__mux2_1
X_2535_ _2880_/Q _2423_/X _2532_/X _2534_/X VGND VGND VPWR VPWR _2880_/D sky130_fd_sc_hd__o22a_1
X_2397_ _2851_/Q _1605_/X _2400_/S VGND VGND VPWR VPWR _2851_/D sky130_fd_sc_hd__mux2_1
X_1348_ _1988_/A _1690_/A VGND VGND VPWR VPWR _1349_/A sky130_fd_sc_hd__or2_1
XFILLER_59_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2251_ _2771_/Q input46/X _2255_/S VGND VGND VPWR VPWR _2771_/D sky130_fd_sc_hd__mux2_1
XFILLER_2_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2320_ _2811_/Q VGND VGND VPWR VPWR _2571_/A sky130_fd_sc_hd__clkbuf_16
XFILLER_25_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2182_ _2897_/Q _2896_/Q VGND VGND VPWR VPWR _2182_/Y sky130_fd_sc_hd__nor2_1
X_1966_ _2686_/Q _1926_/B _1960_/X _1965_/Y VGND VGND VPWR VPWR _2686_/D sky130_fd_sc_hd__a22o_1
XFILLER_33_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1897_ _1897_/A _1897_/B VGND VGND VPWR VPWR _1932_/A sky130_fd_sc_hd__nor2_1
X_2449_ _2663_/Q _2419_/A _2588_/B _2448_/X _2437_/X VGND VGND VPWR VPWR _2449_/X
+ sky130_fd_sc_hd__a221o_1
X_2518_ _2876_/Q _2873_/Q _2811_/Q VGND VGND VPWR VPWR _2518_/X sky130_fd_sc_hd__mux2_1
XFILLER_17_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1820_ _2670_/Q _1819_/X _1982_/S VGND VGND VPWR VPWR _2670_/D sky130_fd_sc_hd__mux2_1
XFILLER_15_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1682_ _2655_/Q VGND VGND VPWR VPWR _2561_/S sky130_fd_sc_hd__buf_12
X_1751_ _1926_/B _1751_/B _1751_/C VGND VGND VPWR VPWR _1751_/X sky130_fd_sc_hd__or3_1
X_2303_ _2796_/Q _2292_/S _2295_/Y _2829_/Q VGND VGND VPWR VPWR _2796_/D sky130_fd_sc_hd__a22o_1
XFILLER_57_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2234_ _2754_/Q input28/X _2247_/S VGND VGND VPWR VPWR _2754_/D sky130_fd_sc_hd__mux2_1
X_2165_ _2090_/A _2009_/A _2202_/B VGND VGND VPWR VPWR _2165_/Y sky130_fd_sc_hd__a21oi_1
X_2096_ _1988_/A _2261_/B _1688_/B VGND VGND VPWR VPWR _2097_/C sky130_fd_sc_hd__a21oi_1
X_1949_ input5/X VGND VGND VPWR VPWR _2193_/C sky130_fd_sc_hd__inv_2
XFILLER_21_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2783_ _2844_/CLK _2783_/D VGND VGND VPWR VPWR _2783_/Q sky130_fd_sc_hd__dfxtp_1
X_2852_ _2854_/CLK _2852_/D VGND VGND VPWR VPWR _2852_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_43_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1803_ _2193_/B _1509_/A _1784_/C _1765_/Y _1963_/A VGND VGND VPWR VPWR _1803_/X
+ sky130_fd_sc_hd__a32o_1
X_1596_ _2645_/Q _1595_/X _1598_/S VGND VGND VPWR VPWR _2645_/D sky130_fd_sc_hd__mux2_1
X_1734_ _1727_/C _1732_/X _1733_/Y VGND VGND VPWR VPWR _1735_/C sky130_fd_sc_hd__a21oi_1
X_1665_ _1422_/X _1663_/Y _1664_/X _2264_/A VGND VGND VPWR VPWR _1665_/Y sky130_fd_sc_hd__a22oi_1
XFILLER_7_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2217_ _2742_/Q _2223_/S _2214_/X _2216_/Y VGND VGND VPWR VPWR _2742_/D sky130_fd_sc_hd__o22a_1
XFILLER_53_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2148_ _2148_/A _2148_/B VGND VGND VPWR VPWR _2150_/C sky130_fd_sc_hd__nand2_1
X_2079_ _2079_/A _2079_/B VGND VGND VPWR VPWR _2710_/D sky130_fd_sc_hd__nand2_1
XFILLER_30_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1450_ _2728_/Q _1450_/B VGND VGND VPWR VPWR _1451_/B sky130_fd_sc_hd__xor2_1
X_1381_ _1418_/A _2690_/Q _2689_/Q VGND VGND VPWR VPWR _2258_/B sky130_fd_sc_hd__or3_1
XFILLER_50_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2002_ _1645_/Y _2123_/B _1930_/Y _2001_/X _1897_/A VGND VGND VPWR VPWR _2002_/X
+ sky130_fd_sc_hd__o32a_1
X_2835_ _2836_/CLK _2835_/D VGND VGND VPWR VPWR _2835_/Q sky130_fd_sc_hd__dfxtp_1
X_2766_ _2897_/CLK _2766_/D VGND VGND VPWR VPWR _2766_/Q sky130_fd_sc_hd__dfxtp_1
X_1579_ _2636_/Q _2633_/Q _2399_/S VGND VGND VPWR VPWR _1579_/X sky130_fd_sc_hd__mux2_1
X_2697_ _2775_/CLK _2697_/D VGND VGND VPWR VPWR _2697_/Q sky130_fd_sc_hd__dfxtp_2
X_1648_ _1363_/B _2717_/Q _1706_/A VGND VGND VPWR VPWR _1648_/Y sky130_fd_sc_hd__a21oi_1
X_1717_ _2737_/Q _2775_/Q VGND VGND VPWR VPWR _1717_/Y sky130_fd_sc_hd__nand2_1
XTAP_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2620_ _2838_/CLK _2620_/D VGND VGND VPWR VPWR _2620_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_9_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1433_ _1988_/A _1433_/B VGND VGND VPWR VPWR _2258_/A sky130_fd_sc_hd__nor2_2
X_1502_ input7/X _1502_/B VGND VGND VPWR VPWR _1511_/C sky130_fd_sc_hd__xnor2_1
X_2482_ _2562_/A _2594_/B _2482_/C VGND VGND VPWR VPWR _2482_/X sky130_fd_sc_hd__and3_1
X_2551_ _2571_/A _2883_/Q VGND VGND VPWR VPWR _2551_/X sky130_fd_sc_hd__or2_1
X_1364_ _1941_/B _2205_/A _1897_/B VGND VGND VPWR VPWR _1748_/B sky130_fd_sc_hd__o21bai_4
XFILLER_63_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2749_ _2816_/CLK _2749_/D VGND VGND VPWR VPWR _2749_/Q sky130_fd_sc_hd__dfxtp_2
X_2818_ _2893_/CLK _2818_/D VGND VGND VPWR VPWR _2818_/Q sky130_fd_sc_hd__dfxtp_4
XTAP_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput19 i_wb_addr[4] VGND VGND VPWR VPWR _1770_/B sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_37_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1982_ _2688_/Q _1981_/X _1982_/S VGND VGND VPWR VPWR _2688_/D sky130_fd_sc_hd__mux2_1
XFILLER_20_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2603_ _2606_/A _2404_/Y _2601_/Y VGND VGND VPWR VPWR _2603_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_9_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2534_ _2680_/Q _2419_/A _2588_/B _2533_/X _2437_/X VGND VGND VPWR VPWR _2534_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_13_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2396_ _2850_/Q _1603_/X _2400_/S VGND VGND VPWR VPWR _2850_/D sky130_fd_sc_hd__mux2_1
X_1416_ _2150_/A _1416_/B VGND VGND VPWR VPWR _2619_/D sky130_fd_sc_hd__or2_1
X_1347_ _2742_/Q _2741_/Q VGND VGND VPWR VPWR _1690_/A sky130_fd_sc_hd__nand2b_4
X_2465_ _2866_/Q _2423_/X _2462_/X _2464_/X VGND VGND VPWR VPWR _2866_/D sky130_fd_sc_hd__o22a_1
XFILLER_36_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2250_ _2770_/Q input45/X _2255_/S VGND VGND VPWR VPWR _2770_/D sky130_fd_sc_hd__mux2_1
XFILLER_2_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2181_ _2202_/A _2609_/C _1986_/Y VGND VGND VPWR VPWR _2181_/X sky130_fd_sc_hd__o21a_1
XFILLER_25_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1965_ _2262_/B _1964_/X _1926_/B VGND VGND VPWR VPWR _1965_/Y sky130_fd_sc_hd__a21oi_1
X_1896_ _2264_/A _2681_/Q _1706_/B _1678_/D _2193_/B VGND VGND VPWR VPWR _1896_/X
+ sky130_fd_sc_hd__a311o_1
X_2517_ _2562_/A _2594_/B _2517_/C VGND VGND VPWR VPWR _2517_/X sky130_fd_sc_hd__and3_1
X_2379_ _2833_/Q _1569_/X _2819_/D VGND VGND VPWR VPWR _2833_/D sky130_fd_sc_hd__mux2_1
XFILLER_56_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2448_ _2662_/Q _2659_/Q _2561_/S VGND VGND VPWR VPWR _2448_/X sky130_fd_sc_hd__mux2_1
XFILLER_33_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1750_ _2193_/B input5/X _1784_/C _1787_/A _2659_/Q VGND VGND VPWR VPWR _1751_/C
+ sky130_fd_sc_hd__a32o_1
X_1681_ _1672_/Y _1680_/B _1680_/X VGND VGND VPWR VPWR _2654_/D sky130_fd_sc_hd__a21boi_1
X_2302_ _2795_/Q _2292_/S _2295_/Y _2828_/Q VGND VGND VPWR VPWR _2795_/D sky130_fd_sc_hd__a22o_1
XFILLER_38_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2164_ _1897_/A _2161_/X _2162_/Y _2163_/X VGND VGND VPWR VPWR _2164_/X sky130_fd_sc_hd__a31o_1
X_2233_ _2753_/Q input58/X _2247_/S VGND VGND VPWR VPWR _2753_/D sky130_fd_sc_hd__mux2_1
XFILLER_61_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2095_ _2127_/A _2093_/Y _2094_/X VGND VGND VPWR VPWR _2130_/A sky130_fd_sc_hd__a21oi_1
XFILLER_21_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1879_ _2677_/Q _1742_/B _1878_/X _1982_/S VGND VGND VPWR VPWR _2677_/D sky130_fd_sc_hd__a22o_1
X_1948_ _1505_/A _1765_/Y _1947_/X _2402_/S VGND VGND VPWR VPWR _1948_/X sky130_fd_sc_hd__a22o_1
XFILLER_21_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2782_ _2844_/CLK _2782_/D VGND VGND VPWR VPWR _2782_/Q sky130_fd_sc_hd__dfxtp_1
X_2851_ _2854_/CLK _2851_/D VGND VGND VPWR VPWR _2851_/Q sky130_fd_sc_hd__dfxtp_1
X_1733_ _2205_/B _1733_/B VGND VGND VPWR VPWR _1733_/Y sky130_fd_sc_hd__nor2_1
X_1802_ _2725_/Q _1763_/B _1801_/X VGND VGND VPWR VPWR _1802_/X sky130_fd_sc_hd__a21o_1
XTAP_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1595_ _2644_/Q _2641_/Q _2818_/Q VGND VGND VPWR VPWR _1595_/X sky130_fd_sc_hd__mux2_1
XTAP_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1664_ _1914_/B _2692_/Q _2691_/Q VGND VGND VPWR VPWR _1664_/X sky130_fd_sc_hd__a21o_1
XTAP_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2147_ _1988_/C _2258_/A _2258_/B _2145_/X _2146_/X VGND VGND VPWR VPWR _2150_/B
+ sky130_fd_sc_hd__a311o_1
XFILLER_38_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2216_ _2264_/A _2215_/X _2197_/A VGND VGND VPWR VPWR _2216_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_26_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2078_ _2710_/Q _2077_/B _2087_/A VGND VGND VPWR VPWR _2079_/B sky130_fd_sc_hd__a21oi_1
XFILLER_14_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1380_ _2819_/Q VGND VGND VPWR VPWR _1418_/A sky130_fd_sc_hd__clkinv_2
X_2001_ _2821_/Q _2736_/Q _2001_/C _2001_/D VGND VGND VPWR VPWR _2001_/X sky130_fd_sc_hd__and4bb_1
XFILLER_23_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2834_ _2836_/CLK _2834_/D VGND VGND VPWR VPWR _2834_/Q sky130_fd_sc_hd__dfxtp_1
X_2696_ _2824_/CLK _2696_/D VGND VGND VPWR VPWR _2696_/Q sky130_fd_sc_hd__dfxtp_1
X_2765_ _2775_/CLK _2765_/D VGND VGND VPWR VPWR _2765_/Q sky130_fd_sc_hd__dfxtp_1
X_1716_ _2716_/Q _2717_/Q VGND VGND VPWR VPWR _2205_/C sky130_fd_sc_hd__nor2_1
X_1578_ _2636_/Q _1577_/X _1598_/S VGND VGND VPWR VPWR _2636_/D sky130_fd_sc_hd__mux2_1
X_1647_ _1782_/A VGND VGND VPWR VPWR _1706_/A sky130_fd_sc_hd__inv_2
XTAP_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2550_ _2883_/Q _2423_/X _2547_/X _2549_/X VGND VGND VPWR VPWR _2883_/D sky130_fd_sc_hd__o22a_1
XFILLER_15_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1501_ _1450_/B _1501_/B VGND VGND VPWR VPWR _1502_/B sky130_fd_sc_hd__and2b_1
X_1363_ _1782_/A _1363_/B VGND VGND VPWR VPWR _1897_/B sky130_fd_sc_hd__nor2_2
X_2481_ _2669_/Q _2666_/Q _2561_/S VGND VGND VPWR VPWR _2482_/C sky130_fd_sc_hd__mux2_1
X_1432_ _2821_/Q _2001_/C VGND VGND VPWR VPWR _1988_/C sky130_fd_sc_hd__nand2b_2
X_2817_ _2857_/CLK _2817_/D VGND VGND VPWR VPWR _2817_/Q sky130_fd_sc_hd__dfxtp_1
X_2748_ _2748_/CLK _2748_/D VGND VGND VPWR VPWR _2748_/Q sky130_fd_sc_hd__dfxtp_2
X_2679_ _2883_/CLK _2679_/D VGND VGND VPWR VPWR _2679_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1981_ _2016_/S _1976_/X _1977_/X _1980_/X VGND VGND VPWR VPWR _1981_/X sky130_fd_sc_hd__a2bb2o_1
XFILLER_61_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2602_ _2577_/Y _2424_/Y _2425_/Y VGND VGND VPWR VPWR _2602_/X sky130_fd_sc_hd__a21o_1
X_2533_ _2679_/Q _2676_/Q _2655_/Q VGND VGND VPWR VPWR _2533_/X sky130_fd_sc_hd__mux2_1
X_2395_ _2849_/Q _1601_/X _2400_/S VGND VGND VPWR VPWR _2849_/D sky130_fd_sc_hd__mux2_1
X_1415_ _1388_/X _2270_/A _1727_/C _1398_/X _1414_/Y VGND VGND VPWR VPWR _1416_/B
+ sky130_fd_sc_hd__a221o_1
X_1346_ _2692_/Q _2737_/Q _1782_/A VGND VGND VPWR VPWR _1538_/B sky130_fd_sc_hd__a21oi_1
XFILLER_28_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2464_ _2666_/Q _2419_/A _2588_/B _2463_/X _2437_/X VGND VGND VPWR VPWR _2464_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_36_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2180_ _2821_/Q _2180_/B VGND VGND VPWR VPWR _2180_/X sky130_fd_sc_hd__or2_1
XFILLER_33_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1964_ _1961_/Y _1962_/Y _1963_/X _1928_/A VGND VGND VPWR VPWR _1964_/X sky130_fd_sc_hd__o22a_1
X_1895_ _2680_/Q _1742_/X _1765_/Y input9/X _1894_/X VGND VGND VPWR VPWR _2680_/D
+ sky130_fd_sc_hd__a221o_1
X_2447_ _2447_/A _2447_/B VGND VGND VPWR VPWR _2588_/B sky130_fd_sc_hd__nor2_8
X_2516_ _2676_/Q _2673_/Q _2561_/S VGND VGND VPWR VPWR _2517_/C sky130_fd_sc_hd__mux2_1
X_2378_ _2832_/Q _1567_/X _2819_/D VGND VGND VPWR VPWR _2832_/D sky130_fd_sc_hd__mux2_1
XFILLER_56_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1329_ _2740_/Q VGND VGND VPWR VPWR _1630_/A sky130_fd_sc_hd__buf_8
XFILLER_33_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2301_ _2794_/Q _2292_/S _2295_/Y _2827_/Q VGND VGND VPWR VPWR _2794_/D sky130_fd_sc_hd__a22o_1
X_1680_ _2125_/A _1680_/B _1680_/C _1680_/D VGND VGND VPWR VPWR _1680_/X sky130_fd_sc_hd__or4_1
X_2163_ _1706_/A _2736_/Q _1932_/A _1712_/B _2090_/A VGND VGND VPWR VPWR _2163_/X
+ sky130_fd_sc_hd__a32o_1
XFILLER_2_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2232_ _2752_/Q input57/X _2247_/S VGND VGND VPWR VPWR _2752_/D sky130_fd_sc_hd__mux2_1
XFILLER_61_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2094_ _2653_/Q _2609_/A _2209_/A VGND VGND VPWR VPWR _2094_/X sky130_fd_sc_hd__and3_1
X_1878_ _2677_/Q _1787_/A _1872_/X _1877_/X VGND VGND VPWR VPWR _1878_/X sky130_fd_sc_hd__a211o_1
X_1947_ _2205_/B _1942_/X _1946_/X _1696_/B VGND VGND VPWR VPWR _1947_/X sky130_fd_sc_hd__a2bb2o_1
XFILLER_9_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2850_ _2850_/CLK _2850_/D VGND VGND VPWR VPWR _2850_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_47_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2781_ _2844_/CLK _2781_/D VGND VGND VPWR VPWR _2781_/Q sky130_fd_sc_hd__dfxtp_1
X_1732_ _2193_/B _1731_/C _1421_/Y _1731_/X VGND VGND VPWR VPWR _1732_/X sky130_fd_sc_hd__a211o_1
X_1663_ _1726_/A _1782_/B _1662_/Y VGND VGND VPWR VPWR _1663_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_7_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1801_ _2747_/Q _2123_/B _1800_/X VGND VGND VPWR VPWR _1801_/X sky130_fd_sc_hd__a21o_1
XTAP_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1594_ _2644_/Q _1593_/X _1598_/S VGND VGND VPWR VPWR _2644_/D sky130_fd_sc_hd__mux2_1
XTAP_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2146_ _2013_/B _2188_/C _2821_/Q VGND VGND VPWR VPWR _2146_/X sky130_fd_sc_hd__o21a_1
X_2215_ _2193_/A _1914_/B _1726_/Y _1725_/X _2016_/S VGND VGND VPWR VPWR _2215_/X
+ sky130_fd_sc_hd__a41o_1
X_2077_ _2710_/Q _2077_/B VGND VGND VPWR VPWR _2079_/A sky130_fd_sc_hd__or2_1
XFILLER_41_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2000_ _2000_/A _2000_/B VGND VGND VPWR VPWR _2000_/Y sky130_fd_sc_hd__nand2_1
X_2833_ _2836_/CLK _2833_/D VGND VGND VPWR VPWR _2833_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_50_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2695_ _2824_/CLK _2695_/D VGND VGND VPWR VPWR _2695_/Q sky130_fd_sc_hd__dfxtp_2
X_2764_ _2775_/CLK _2764_/D VGND VGND VPWR VPWR _2764_/Q sky130_fd_sc_hd__dfxtp_1
X_1646_ _2202_/A _2009_/B _1644_/X _1645_/Y _2013_/B VGND VGND VPWR VPWR _1646_/X
+ sky130_fd_sc_hd__a2111o_1
X_1715_ _2272_/C _2083_/B VGND VGND VPWR VPWR _2738_/D sky130_fd_sc_hd__nand2_1
XFILLER_58_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1577_ _2635_/Q _2632_/Q _2399_/S VGND VGND VPWR VPWR _1577_/X sky130_fd_sc_hd__mux2_1
XTAP_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2129_ _1410_/C _2097_/C _2129_/C _2129_/D VGND VGND VPWR VPWR _2130_/C sky130_fd_sc_hd__and4bb_1
XPHY_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1500_ _1499_/Y _1508_/A _2727_/Q VGND VGND VPWR VPWR _1501_/B sky130_fd_sc_hd__o21bai_1
X_2480_ _2869_/Q _2423_/X _2477_/X _2479_/X VGND VGND VPWR VPWR _2869_/D sky130_fd_sc_hd__o22a_1
XFILLER_9_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput90 _2785_/Q VGND VGND VPWR VPWR o_wb_data[27] sky130_fd_sc_hd__clkbuf_1
X_1431_ _1835_/A _2129_/D VGND VGND VPWR VPWR _1984_/A sky130_fd_sc_hd__or2_2
X_1362_ _1782_/A _1363_/B VGND VGND VPWR VPWR _2205_/A sky130_fd_sc_hd__nand2_4
XFILLER_63_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2816_ _2816_/CLK _2816_/D VGND VGND VPWR VPWR _2816_/Q sky130_fd_sc_hd__dfxtp_1
X_1629_ _1433_/B _1983_/A _2098_/A VGND VGND VPWR VPWR _1686_/B sky130_fd_sc_hd__a21oi_1
X_2678_ _2730_/CLK _2678_/D VGND VGND VPWR VPWR _2678_/Q sky130_fd_sc_hd__dfxtp_1
X_2747_ _2748_/CLK _2747_/D VGND VGND VPWR VPWR _2747_/Q sky130_fd_sc_hd__dfxtp_2
XFILLER_54_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1980_ _2188_/C _1990_/B _1980_/C _1980_/D VGND VGND VPWR VPWR _1980_/X sky130_fd_sc_hd__or4_1
XFILLER_54_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2463_ _2665_/Q _2662_/Q _2561_/S VGND VGND VPWR VPWR _2463_/X sky130_fd_sc_hd__mux2_1
X_2601_ _2571_/A _2415_/B _2600_/S VGND VGND VPWR VPWR _2601_/Y sky130_fd_sc_hd__a21oi_1
X_2532_ _2606_/A _2876_/Q _2343_/X _2531_/X VGND VGND VPWR VPWR _2532_/X sky130_fd_sc_hd__o211a_1
X_2394_ _2848_/Q _1599_/X _2400_/S VGND VGND VPWR VPWR _2848_/D sky130_fd_sc_hd__mux2_1
X_1345_ _2777_/Q VGND VGND VPWR VPWR _1782_/A sky130_fd_sc_hd__buf_4
X_1414_ _1414_/A _1419_/B VGND VGND VPWR VPWR _1414_/Y sky130_fd_sc_hd__nor2_1
XFILLER_36_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1963_ _1963_/A _2193_/C VGND VGND VPWR VPWR _1963_/X sky130_fd_sc_hd__or2_1
X_1894_ _2205_/B _1894_/B _1894_/C VGND VGND VPWR VPWR _1894_/X sky130_fd_sc_hd__and3_1
X_2515_ _2876_/Q _2423_/X _2512_/X _2514_/X VGND VGND VPWR VPWR _2876_/D sky130_fd_sc_hd__o22a_1
X_2446_ _2606_/A _2859_/Q _2343_/X _2445_/X VGND VGND VPWR VPWR _2446_/X sky130_fd_sc_hd__o211a_1
X_2377_ _2831_/Q _1565_/X _2819_/D VGND VGND VPWR VPWR _2831_/D sky130_fd_sc_hd__mux2_1
X_1328_ _2739_/Q VGND VGND VPWR VPWR _2090_/A sky130_fd_sc_hd__buf_12
XFILLER_33_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2300_ _2793_/Q _2292_/S _2295_/Y _2826_/Q VGND VGND VPWR VPWR _2793_/D sky130_fd_sc_hd__a22o_1
XFILLER_2_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2231_ _2751_/Q input56/X _2247_/S VGND VGND VPWR VPWR _2751_/D sky130_fd_sc_hd__mux2_1
X_2093_ _2209_/B VGND VGND VPWR VPWR _2093_/Y sky130_fd_sc_hd__inv_2
XFILLER_17_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2162_ _2736_/Q _2162_/B VGND VGND VPWR VPWR _2162_/Y sky130_fd_sc_hd__nand2_1
X_1877_ _2726_/Q _1899_/B _1876_/X VGND VGND VPWR VPWR _1877_/X sky130_fd_sc_hd__o21a_1
X_1946_ _2734_/Q _2012_/A _1944_/X _1945_/X VGND VGND VPWR VPWR _1946_/X sky130_fd_sc_hd__a22o_1
XFILLER_9_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2429_ _2858_/Q _2424_/Y _2425_/Y _2658_/Q _2426_/Y VGND VGND VPWR VPWR _2429_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_44_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1800_ _2755_/Q _2013_/B _2012_/A _2717_/Q VGND VGND VPWR VPWR _1800_/X sky130_fd_sc_hd__a22o_1
X_2780_ _2836_/CLK _2780_/D VGND VGND VPWR VPWR _2780_/Q sky130_fd_sc_hd__dfxtp_1
X_1731_ _1731_/A _2692_/Q _1731_/C VGND VGND VPWR VPWR _1731_/X sky130_fd_sc_hd__and3_1
X_1662_ _1662_/A _1662_/B VGND VGND VPWR VPWR _1662_/Y sky130_fd_sc_hd__nor2_1
XFILLER_7_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1593_ _2643_/Q _2640_/Q _2399_/S VGND VGND VPWR VPWR _1593_/X sky130_fd_sc_hd__mux2_1
XTAP_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2214_ _2210_/Y _2213_/X _2205_/B _1538_/D VGND VGND VPWR VPWR _2214_/X sky130_fd_sc_hd__o2bb2a_1
XFILLER_53_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2145_ _2259_/B _1675_/Y _1727_/X _1662_/B VGND VGND VPWR VPWR _2145_/X sky130_fd_sc_hd__a2bb2o_1
X_2076_ _2077_/B _2076_/B VGND VGND VPWR VPWR _2709_/D sky130_fd_sc_hd__nand2_1
XFILLER_61_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1929_ _2264_/A _2684_/Q _1706_/B _1928_/Y VGND VGND VPWR VPWR _1929_/X sky130_fd_sc_hd__a31o_1
XFILLER_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2832_ _2836_/CLK _2832_/D VGND VGND VPWR VPWR _2832_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_50_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2763_ _2775_/CLK _2763_/D VGND VGND VPWR VPWR _2763_/Q sky130_fd_sc_hd__dfxtp_1
X_1576_ _2635_/Q _1575_/X _1598_/S VGND VGND VPWR VPWR _2635_/D sky130_fd_sc_hd__mux2_1
X_2694_ _2824_/CLK _2694_/D VGND VGND VPWR VPWR _2694_/Q sky130_fd_sc_hd__dfxtp_1
X_1714_ _2027_/S _2014_/A _2048_/A VGND VGND VPWR VPWR _2610_/A sky130_fd_sc_hd__or3_2
X_1645_ _1897_/A _2180_/B VGND VGND VPWR VPWR _1645_/Y sky130_fd_sc_hd__nand2_2
XFILLER_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2128_ _2122_/X _2736_/Q _2128_/S VGND VGND VPWR VPWR _2736_/D sky130_fd_sc_hd__mux2_1
XFILLER_34_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2059_ _2272_/C _2059_/B VGND VGND VPWR VPWR _2703_/D sky130_fd_sc_hd__and2_1
XPHY_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1430_ _1988_/A _1838_/A VGND VGND VPWR VPWR _2129_/D sky130_fd_sc_hd__or2_2
Xoutput80 _2783_/Q VGND VGND VPWR VPWR o_wb_data[18] sky130_fd_sc_hd__clkbuf_1
Xoutput91 _2786_/Q VGND VGND VPWR VPWR o_wb_data[28] sky130_fd_sc_hd__clkbuf_1
X_1361_ _2717_/Q VGND VGND VPWR VPWR _1941_/B sky130_fd_sc_hd__clkinv_2
XFILLER_63_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2815_ _2895_/CLK _2815_/D VGND VGND VPWR VPWR _2815_/Q sky130_fd_sc_hd__dfxtp_1
X_2746_ _2748_/CLK _2746_/D VGND VGND VPWR VPWR _2746_/Q sky130_fd_sc_hd__dfxtp_2
X_1559_ _2626_/Q _2623_/Q _2399_/S VGND VGND VPWR VPWR _1559_/X sky130_fd_sc_hd__mux2_1
X_1628_ _1628_/A _1635_/B _2135_/B _2014_/A VGND VGND VPWR VPWR _1983_/A sky130_fd_sc_hd__or4_1
X_2677_ _2730_/CLK _2677_/D VGND VGND VPWR VPWR _2677_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2600_ _2599_/X _2893_/Q _2600_/S VGND VGND VPWR VPWR _2893_/D sky130_fd_sc_hd__mux2_1
XFILLER_20_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1413_ _2098_/A _1413_/B VGND VGND VPWR VPWR _1419_/B sky130_fd_sc_hd__or2_1
XFILLER_47_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2393_ _2847_/Q _1597_/X _2400_/S VGND VGND VPWR VPWR _2847_/D sky130_fd_sc_hd__mux2_1
X_2462_ _2606_/A _2862_/Q _2343_/X _2461_/X VGND VGND VPWR VPWR _2462_/X sky130_fd_sc_hd__o211a_1
XFILLER_5_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2531_ _2571_/A _2879_/Q VGND VGND VPWR VPWR _2531_/X sky130_fd_sc_hd__or2_1
X_1344_ _2001_/C _2202_/A VGND VGND VPWR VPWR _2018_/B sky130_fd_sc_hd__nand2_2
XFILLER_51_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2729_ _2730_/CLK _2729_/D VGND VGND VPWR VPWR _2729_/Q sky130_fd_sc_hd__dfxtp_2
XFILLER_47_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_2_0__f_i_clk clkbuf_0_i_clk/X VGND VGND VPWR VPWR clkbuf_leaf_3_i_clk/A sky130_fd_sc_hd__clkbuf_16
XFILLER_18_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1962_ _1914_/B _2736_/Q _2264_/A VGND VGND VPWR VPWR _1962_/Y sky130_fd_sc_hd__o21ai_1
X_1893_ _2767_/Q _1943_/S _1899_/B _2729_/Q VGND VGND VPWR VPWR _1894_/C sky130_fd_sc_hd__o22a_1
X_2376_ _2830_/Q _1563_/X _2819_/D VGND VGND VPWR VPWR _2830_/D sky130_fd_sc_hd__mux2_1
X_2445_ _2571_/A _2862_/Q VGND VGND VPWR VPWR _2445_/X sky130_fd_sc_hd__or2_1
X_2514_ _2676_/Q _2419_/A _2343_/X _2513_/X _2437_/X VGND VGND VPWR VPWR _2514_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_64_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1327_ _1327_/A VGND VGND VPWR VPWR _2264_/A sky130_fd_sc_hd__buf_6
XFILLER_59_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2230_ _2750_/Q input55/X _2247_/S VGND VGND VPWR VPWR _2750_/D sky130_fd_sc_hd__mux2_1
X_2092_ _2272_/C _2092_/B VGND VGND VPWR VPWR _2715_/D sky130_fd_sc_hd__nand2_1
X_2161_ _2126_/A _2159_/X _2160_/X _1841_/B VGND VGND VPWR VPWR _2161_/X sky130_fd_sc_hd__a22o_1
XFILLER_0_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1945_ _1897_/A _1934_/Y _2000_/B _1640_/B _2000_/A VGND VGND VPWR VPWR _1945_/X
+ sky130_fd_sc_hd__o2111a_1
XFILLER_9_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1876_ _2734_/Q _1763_/B _1875_/X _2012_/A VGND VGND VPWR VPWR _1876_/X sky130_fd_sc_hd__a211o_1
XFILLER_0_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2428_ _2658_/Q _2562_/A _2423_/X _2858_/Q _2427_/X VGND VGND VPWR VPWR _2858_/D
+ sky130_fd_sc_hd__o221a_1
X_2359_ _2816_/Q _2356_/X _2358_/X VGND VGND VPWR VPWR _2816_/D sky130_fd_sc_hd__o21ba_1
XFILLER_37_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1592_ _2643_/Q _1591_/X _1598_/S VGND VGND VPWR VPWR _2643_/D sky130_fd_sc_hd__mux2_1
X_1730_ _1730_/A VGND VGND VPWR VPWR _2193_/B sky130_fd_sc_hd__buf_8
X_1661_ _2260_/A _1657_/X _1660_/X _2402_/S VGND VGND VPWR VPWR _1661_/X sky130_fd_sc_hd__o211a_1
XFILLER_7_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2144_ _2821_/Q _2001_/C _2143_/Y _2260_/B _1695_/A VGND VGND VPWR VPWR _2152_/B
+ sky130_fd_sc_hd__o32a_1
X_2213_ _1706_/A _1897_/A _2211_/Y _2202_/X _2610_/C VGND VGND VPWR VPWR _2213_/X
+ sky130_fd_sc_hd__o2111a_1
XFILLER_53_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2075_ _2709_/Q _2074_/B _2087_/A VGND VGND VPWR VPWR _2076_/B sky130_fd_sc_hd__a21oi_1
X_1928_ _1928_/A _1928_/B VGND VGND VPWR VPWR _1928_/Y sky130_fd_sc_hd__nor2_1
X_1859_ _2762_/Q _1943_/S _1857_/X _1858_/X _1841_/Y VGND VGND VPWR VPWR _1859_/X
+ sky130_fd_sc_hd__o221a_1
XFILLER_44_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2831_ _2836_/CLK _2831_/D VGND VGND VPWR VPWR _2831_/Q sky130_fd_sc_hd__dfxtp_1
X_2762_ _2775_/CLK _2762_/D VGND VGND VPWR VPWR _2762_/Q sky130_fd_sc_hd__dfxtp_1
X_1713_ _2013_/B _1713_/B _1983_/B VGND VGND VPWR VPWR _2048_/A sky130_fd_sc_hd__or3_1
X_1575_ _2634_/Q _2631_/Q _2399_/S VGND VGND VPWR VPWR _1575_/X sky130_fd_sc_hd__mux2_1
X_2693_ _2824_/CLK _2693_/D VGND VGND VPWR VPWR _2693_/Q sky130_fd_sc_hd__dfxtp_2
X_1644_ _1733_/B _2609_/B _1698_/C _1643_/X VGND VGND VPWR VPWR _1644_/X sky130_fd_sc_hd__o22a_1
XTAP_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2127_ _2127_/A _2127_/B _2127_/C _2127_/D VGND VGND VPWR VPWR _2128_/S sky130_fd_sc_hd__or4_1
XTAP_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2058_ _2057_/X _2703_/Q _2064_/S VGND VGND VPWR VPWR _2059_/B sky130_fd_sc_hd__mux2_1
XPHY_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput70 _2619_/Q VGND VGND VPWR VPWR o_wb_ack sky130_fd_sc_hd__clkbuf_1
X_1360_ _1988_/A _1988_/B VGND VGND VPWR VPWR _1897_/A sky130_fd_sc_hd__nand2_4
Xoutput81 _2784_/Q VGND VGND VPWR VPWR o_wb_data[19] sky130_fd_sc_hd__clkbuf_1
Xoutput92 _2787_/Q VGND VGND VPWR VPWR o_wb_data[29] sky130_fd_sc_hd__clkbuf_1
XFILLER_31_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2676_ _2724_/CLK _2676_/D VGND VGND VPWR VPWR _2676_/Q sky130_fd_sc_hd__dfxtp_1
X_2814_ _2895_/CLK _2814_/D VGND VGND VPWR VPWR _2814_/Q sky130_fd_sc_hd__dfxtp_1
X_2745_ _2748_/CLK _2745_/D VGND VGND VPWR VPWR _2745_/Q sky130_fd_sc_hd__dfxtp_2
X_1558_ _2626_/Q _1557_/X _1598_/S VGND VGND VPWR VPWR _2626_/D sky130_fd_sc_hd__mux2_1
X_1627_ _1627_/A _1838_/B VGND VGND VPWR VPWR _2014_/A sky130_fd_sc_hd__nor2_1
X_1489_ _1489_/A _1489_/B VGND VGND VPWR VPWR _1489_/Y sky130_fd_sc_hd__xnor2_1
XTAP_162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2530_ _2879_/Q _2423_/X _2527_/X _2529_/X VGND VGND VPWR VPWR _2879_/D sky130_fd_sc_hd__o22a_1
X_2392_ _2846_/Q _1595_/X _2819_/D VGND VGND VPWR VPWR _2846_/D sky130_fd_sc_hd__mux2_1
X_1412_ _1630_/A _1690_/A _1612_/A VGND VGND VPWR VPWR _1413_/B sky130_fd_sc_hd__o21a_1
X_1343_ _2653_/Q _2821_/Q VGND VGND VPWR VPWR _2202_/A sky130_fd_sc_hd__nor2_2
XFILLER_3_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2461_ _2571_/A _2865_/Q VGND VGND VPWR VPWR _2461_/X sky130_fd_sc_hd__or2_1
XFILLER_5_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2728_ _2730_/CLK _2728_/D VGND VGND VPWR VPWR _2728_/Q sky130_fd_sc_hd__dfxtp_2
X_2659_ _2883_/CLK _2659_/D VGND VGND VPWR VPWR _2659_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_47_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1961_ _2686_/Q _1706_/B _2193_/B VGND VGND VPWR VPWR _1961_/Y sky130_fd_sc_hd__a21oi_1
X_1892_ _2705_/Q _2123_/B _2614_/B _2751_/Q _1908_/C VGND VGND VPWR VPWR _1894_/B
+ sky130_fd_sc_hd__a221o_1
X_2513_ _2875_/Q _2872_/Q _2571_/A VGND VGND VPWR VPWR _2513_/X sky130_fd_sc_hd__mux2_1
X_2375_ _2829_/Q _1561_/X _2819_/D VGND VGND VPWR VPWR _2829_/D sky130_fd_sc_hd__mux2_1
X_1326_ _1326_/A VGND VGND VPWR VPWR _1914_/B sky130_fd_sc_hd__buf_4
X_2444_ _2862_/Q _2423_/X _2441_/X _2443_/X VGND VGND VPWR VPWR _2862_/D sky130_fd_sc_hd__o22a_1
XFILLER_24_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2160_ _2821_/Q _2090_/A VGND VGND VPWR VPWR _2160_/X sky130_fd_sc_hd__or2b_1
XFILLER_61_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2091_ _2090_/Y _1669_/X _2715_/Q VGND VGND VPWR VPWR _2092_/B sky130_fd_sc_hd__o21ai_1
X_1875_ _2764_/Q _1943_/S _1873_/X _1874_/X _1841_/Y VGND VGND VPWR VPWR _1875_/X
+ sky130_fd_sc_hd__o221a_1
X_1944_ _2090_/A _2180_/B _1943_/X VGND VGND VPWR VPWR _1944_/X sky130_fd_sc_hd__o21a_1
XFILLER_9_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2427_ _2889_/Q _2424_/Y _2425_/Y _2657_/Q _2426_/Y VGND VGND VPWR VPWR _2427_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_56_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2289_ _2850_/Q _2304_/B _2295_/B _2189_/Y VGND VGND VPWR VPWR _2289_/X sky130_fd_sc_hd__a22o_1
XFILLER_37_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1309_ _2820_/Q _2365_/B VGND VGND VPWR VPWR _1309_/Y sky130_fd_sc_hd__nor2_1
X_2358_ _2447_/A _2349_/B _2343_/X _2356_/X _2583_/A VGND VGND VPWR VPWR _2358_/X
+ sky130_fd_sc_hd__o311a_1
XFILLER_52_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1591_ _2642_/Q _2639_/Q _2399_/S VGND VGND VPWR VPWR _1591_/X sky130_fd_sc_hd__mux2_1
XTAP_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1660_ _1733_/B _1659_/X _2205_/B VGND VGND VPWR VPWR _1660_/X sky130_fd_sc_hd__a21o_1
XTAP_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2212_ _1630_/A _2129_/D _1688_/B _1988_/A VGND VGND VPWR VPWR _2610_/C sky130_fd_sc_hd__o22a_1
XFILLER_38_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2143_ _2690_/Q _2689_/Q _2260_/B VGND VGND VPWR VPWR _2143_/Y sky130_fd_sc_hd__a21boi_1
XFILLER_22_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2074_ _2709_/Q _2074_/B VGND VGND VPWR VPWR _2077_/B sky130_fd_sc_hd__or2_1
X_1858_ _2702_/Q _2123_/B _2614_/B _2746_/Q _2013_/B VGND VGND VPWR VPWR _1858_/X
+ sky130_fd_sc_hd__a221o_1
X_1927_ _2683_/Q _1982_/S _1926_/X VGND VGND VPWR VPWR _2683_/D sky130_fd_sc_hd__o21a_1
X_1789_ _2723_/Q _1645_/Y _1748_/Y _1788_/X _1698_/A VGND VGND VPWR VPWR _1789_/X
+ sky130_fd_sc_hd__a311o_1
XFILLER_44_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2830_ _2836_/CLK _2830_/D VGND VGND VPWR VPWR _2830_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_45_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2692_ _2838_/CLK _2692_/D VGND VGND VPWR VPWR _2692_/Q sky130_fd_sc_hd__dfxtp_2
XANTENNA_1 i_qspi_dat[0] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1643_ _1420_/Y _1678_/D _2135_/B _2691_/Q VGND VGND VPWR VPWR _1643_/X sky130_fd_sc_hd__o211a_1
X_1712_ _2012_/D _1712_/B _2202_/B VGND VGND VPWR VPWR _1983_/B sky130_fd_sc_hd__or3b_1
X_2761_ _2775_/CLK _2761_/D VGND VGND VPWR VPWR _2761_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_58_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1574_ _2634_/Q _1573_/X _1598_/S VGND VGND VPWR VPWR _2634_/D sky130_fd_sc_hd__mux2_1
XTAP_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2126_ _2126_/A _2126_/B VGND VGND VPWR VPWR _2127_/D sky130_fd_sc_hd__nand2_1
X_2057_ _2747_/Q _2825_/Q _2615_/B VGND VGND VPWR VPWR _2057_/X sky130_fd_sc_hd__mux2_1
XPHY_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput82 _2790_/Q VGND VGND VPWR VPWR o_wb_data[1] sky130_fd_sc_hd__clkbuf_1
Xoutput93 _2791_/Q VGND VGND VPWR VPWR o_wb_data[2] sky130_fd_sc_hd__clkbuf_1
Xoutput71 _2789_/Q VGND VGND VPWR VPWR o_wb_data[0] sky130_fd_sc_hd__clkbuf_1
XFILLER_48_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2813_ _2895_/CLK _2813_/D VGND VGND VPWR VPWR _2813_/Q sky130_fd_sc_hd__dfxtp_1
X_1626_ _2162_/B _2125_/A VGND VGND VPWR VPWR _1635_/B sky130_fd_sc_hd__or2_1
X_2675_ _2683_/CLK _2675_/D VGND VGND VPWR VPWR _2675_/Q sky130_fd_sc_hd__dfxtp_1
X_2744_ _2748_/CLK _2744_/D VGND VGND VPWR VPWR _2744_/Q sky130_fd_sc_hd__dfxtp_2
XFILLER_8_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1557_ _2625_/Q _2622_/Q _2399_/S VGND VGND VPWR VPWR _1557_/X sky130_fd_sc_hd__mux2_1
X_1488_ _2719_/Q _1488_/B VGND VGND VPWR VPWR _1489_/B sky130_fd_sc_hd__xnor2_1
XTAP_163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2109_ _2723_/Q _1455_/A _2121_/S VGND VGND VPWR VPWR _2723_/D sky130_fd_sc_hd__mux2_1
XFILLER_22_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2460_ _2865_/Q _2423_/X _2457_/X _2459_/X VGND VGND VPWR VPWR _2865_/D sky130_fd_sc_hd__o22a_1
X_2391_ _2845_/Q _1593_/X _2819_/D VGND VGND VPWR VPWR _2845_/D sky130_fd_sc_hd__mux2_1
X_1342_ _1342_/A VGND VGND VPWR VPWR _2018_/C sky130_fd_sc_hd__buf_2
X_1411_ _1841_/A _1712_/B _2274_/A VGND VGND VPWR VPWR _2098_/A sky130_fd_sc_hd__or3_1
XFILLER_51_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1609_ _1685_/A _1676_/A VGND VGND VPWR VPWR _2304_/B sky130_fd_sc_hd__nand2_4
X_2727_ _2854_/CLK _2727_/D VGND VGND VPWR VPWR _2727_/Q sky130_fd_sc_hd__dfxtp_1
X_2589_ _2689_/Q _2419_/A _2600_/S VGND VGND VPWR VPWR _2589_/Y sky130_fd_sc_hd__a21oi_1
X_2658_ _2883_/CLK _2658_/D VGND VGND VPWR VPWR _2658_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_27_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1960_ _1448_/A _1765_/Y _1959_/X _2402_/S VGND VGND VPWR VPWR _1960_/X sky130_fd_sc_hd__a22o_1
XFILLER_33_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1891_ _2679_/Q _1742_/X _1765_/Y input8/X _1890_/X VGND VGND VPWR VPWR _2679_/D
+ sky130_fd_sc_hd__a221o_1
X_2512_ _2562_/A _2594_/B _2512_/C VGND VGND VPWR VPWR _2512_/X sky130_fd_sc_hd__and3_1
X_2443_ _2662_/Q _2419_/A _2343_/X _2442_/X _2437_/X VGND VGND VPWR VPWR _2443_/X
+ sky130_fd_sc_hd__a221o_1
X_2374_ _2828_/Q _1559_/X _2819_/D VGND VGND VPWR VPWR _2828_/D sky130_fd_sc_hd__mux2_1
X_1325_ _2714_/Q _2706_/Q _2715_/Q VGND VGND VPWR VPWR _2618_/D sky130_fd_sc_hd__or3b_1
XFILLER_24_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2090_ _2090_/A _2090_/B VGND VGND VPWR VPWR _2090_/Y sky130_fd_sc_hd__nand2_1
XFILLER_48_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1943_ _2772_/Q _1839_/B _1943_/S VGND VGND VPWR VPWR _1943_/X sky130_fd_sc_hd__mux2_1
X_1874_ _2704_/Q _2123_/B _2614_/B _2748_/Q _2013_/B VGND VGND VPWR VPWR _1874_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_14_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2426_ _2562_/A _2583_/B VGND VGND VPWR VPWR _2426_/Y sky130_fd_sc_hd__nand2_1
X_2288_ _2287_/X _2785_/Q _2292_/S VGND VGND VPWR VPWR _2785_/D sky130_fd_sc_hd__mux2_1
X_2357_ _2357_/A _2447_/A VGND VGND VPWR VPWR _2583_/A sky130_fd_sc_hd__nand2_1
XFILLER_29_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1308_ _2323_/B _2334_/B VGND VGND VPWR VPWR _2365_/B sky130_fd_sc_hd__or2_4
XFILLER_52_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1590_ _2642_/Q _1589_/X _1598_/S VGND VGND VPWR VPWR _2642_/D sky130_fd_sc_hd__mux2_1
XTAP_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2211_ _2211_/A _2260_/B VGND VGND VPWR VPWR _2211_/Y sky130_fd_sc_hd__nor2_1
XFILLER_38_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2142_ _2142_/A _2142_/B _2142_/C _2141_/X VGND VGND VPWR VPWR _2152_/A sky130_fd_sc_hd__or4b_1
XFILLER_26_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2073_ _2087_/A _2073_/B _2074_/B VGND VGND VPWR VPWR _2708_/D sky130_fd_sc_hd__or3b_1
XFILLER_15_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1857_ _2760_/Q _2027_/S VGND VGND VPWR VPWR _1857_/X sky130_fd_sc_hd__and2_1
X_1926_ _2172_/A _1926_/B _1926_/C VGND VGND VPWR VPWR _1926_/X sky130_fd_sc_hd__or3_1
X_1788_ _2753_/Q _2013_/B _2123_/B _2745_/Q VGND VGND VPWR VPWR _1788_/X sky130_fd_sc_hd__a22o_1
X_2409_ _2365_/A _2404_/Y _2583_/A VGND VGND VPWR VPWR _2410_/B sky130_fd_sc_hd__o21ai_1
XFILLER_29_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2691_ _2824_/CLK _2691_/D VGND VGND VPWR VPWR _2691_/Q sky130_fd_sc_hd__dfxtp_4
X_1642_ _2653_/Q _1988_/C VGND VGND VPWR VPWR _1733_/B sky130_fd_sc_hd__nor2_1
X_2760_ _2896_/CLK _2760_/D VGND VGND VPWR VPWR _2760_/Q sky130_fd_sc_hd__dfxtp_1
XANTENNA_2 i_wb_addr[12] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1711_ _2180_/B _2126_/B VGND VGND VPWR VPWR _2012_/D sky130_fd_sc_hd__nand2_1
XFILLER_6_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1573_ _2633_/Q _2630_/Q _2399_/S VGND VGND VPWR VPWR _1573_/X sky130_fd_sc_hd__mux2_1
XTAP_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2056_ _2272_/C _2056_/B VGND VGND VPWR VPWR _2702_/D sky130_fd_sc_hd__and2_1
X_2125_ _2125_/A VGND VGND VPWR VPWR _2126_/A sky130_fd_sc_hd__inv_2
XPHY_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1909_ _2716_/Q _1941_/B _2205_/A VGND VGND VPWR VPWR _1932_/B sky130_fd_sc_hd__or3_1
X_2889_ _2889_/CLK _2889_/D VGND VGND VPWR VPWR _2889_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_13_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput83 _2803_/Q VGND VGND VPWR VPWR o_wb_data[20] sky130_fd_sc_hd__clkbuf_1
Xoutput61 _2652_/Q VGND VGND VPWR VPWR o_interrupt sky130_fd_sc_hd__clkbuf_1
Xoutput72 _2799_/Q VGND VGND VPWR VPWR o_wb_data[10] sky130_fd_sc_hd__clkbuf_1
Xoutput94 _2788_/Q VGND VGND VPWR VPWR o_wb_data[30] sky130_fd_sc_hd__clkbuf_1
XFILLER_0_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2743_ _2743_/CLK _2743_/D VGND VGND VPWR VPWR _2743_/Q sky130_fd_sc_hd__dfxtp_1
X_2812_ _2895_/CLK _2812_/D VGND VGND VPWR VPWR _2812_/Q sky130_fd_sc_hd__dfxtp_1
X_1556_ _2625_/Q _1555_/X _1598_/S VGND VGND VPWR VPWR _2625_/D sky130_fd_sc_hd__mux2_1
X_1625_ _1943_/S _2180_/B VGND VGND VPWR VPWR _2125_/A sky130_fd_sc_hd__nand2_2
X_2674_ _2683_/CLK _2674_/D VGND VGND VPWR VPWR _2674_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_54_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1487_ _1480_/Y _1481_/X _1484_/X _1485_/Y _1486_/X VGND VGND VPWR VPWR _1487_/X
+ sky130_fd_sc_hd__o221a_1
XTAP_164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2039_ _2732_/Q _2036_/B _2697_/Q _2037_/Y _2038_/Y VGND VGND VPWR VPWR _2039_/X
+ sky130_fd_sc_hd__o221a_1
XFILLER_22_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2108_ _2722_/Q _1784_/B _2121_/S VGND VGND VPWR VPWR _2722_/D sky130_fd_sc_hd__mux2_1
XFILLER_22_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1410_ _2122_/S _1617_/B _1410_/C _1410_/D VGND VGND VPWR VPWR _2274_/A sky130_fd_sc_hd__or4_2
X_2390_ _2844_/Q _1591_/X _2819_/D VGND VGND VPWR VPWR _2844_/D sky130_fd_sc_hd__mux2_1
X_1341_ _2716_/Q _2717_/Q VGND VGND VPWR VPWR _1342_/A sky130_fd_sc_hd__or2_1
XFILLER_3_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2726_ _2730_/CLK _2726_/D VGND VGND VPWR VPWR _2726_/Q sky130_fd_sc_hd__dfxtp_1
X_1608_ _2651_/Q _1607_/X _1608_/S VGND VGND VPWR VPWR _2651_/D sky130_fd_sc_hd__mux2_1
X_1539_ _1530_/X _2260_/A _1535_/Y _1538_/X VGND VGND VPWR VPWR _1539_/X sky130_fd_sc_hd__o31a_1
X_2588_ _2588_/A _2588_/B VGND VGND VPWR VPWR _2588_/Y sky130_fd_sc_hd__nand2_1
X_2657_ _2883_/CLK _2657_/D VGND VGND VPWR VPWR _2657_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_47_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1890_ _2205_/B _1890_/B _1890_/C VGND VGND VPWR VPWR _1890_/X sky130_fd_sc_hd__and3_1
X_2373_ _2827_/Q _1557_/X _2819_/D VGND VGND VPWR VPWR _2827_/D sky130_fd_sc_hd__mux2_1
X_2442_ _2861_/Q _2858_/Q _2571_/A VGND VGND VPWR VPWR _2442_/X sky130_fd_sc_hd__mux2_1
X_2511_ _2675_/Q _2672_/Q _2561_/S VGND VGND VPWR VPWR _2512_/C sky130_fd_sc_hd__mux2_1
XFILLER_56_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1324_ _2738_/Q _2815_/Q VGND VGND VPWR VPWR _1324_/X sky130_fd_sc_hd__and2b_1
XFILLER_24_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2709_ _2816_/CLK _2709_/D VGND VGND VPWR VPWR _2709_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_17_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1942_ _1940_/Y _1923_/B _1941_/Y _2205_/A VGND VGND VPWR VPWR _1942_/X sky130_fd_sc_hd__o22a_1
XFILLER_14_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1873_ _2762_/Q _2027_/S VGND VGND VPWR VPWR _1873_/X sky130_fd_sc_hd__and2_1
XFILLER_9_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2425_ _2561_/S _2447_/B VGND VGND VPWR VPWR _2425_/Y sky130_fd_sc_hd__nor2_2
X_2356_ _2856_/Q _2323_/B _2606_/B _2355_/Y VGND VGND VPWR VPWR _2356_/X sky130_fd_sc_hd__o31a_1
XFILLER_64_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2287_ _2849_/Q _2304_/B _2295_/B _2736_/Q VGND VGND VPWR VPWR _2287_/X sky130_fd_sc_hd__a22o_1
XFILLER_44_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1307_ _2857_/Q _2856_/Q VGND VGND VPWR VPWR _2334_/B sky130_fd_sc_hd__nand2b_4
XFILLER_52_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2210_ _2210_/A _2210_/B VGND VGND VPWR VPWR _2210_/Y sky130_fd_sc_hd__nand2_1
XFILLER_53_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2141_ _2349_/A _1614_/B _2139_/X _1899_/B _2140_/X VGND VGND VPWR VPWR _2141_/X
+ sky130_fd_sc_hd__o221a_1
X_2072_ _2708_/Q _2707_/Q _2072_/C VGND VGND VPWR VPWR _2074_/B sky130_fd_sc_hd__or3_1
XFILLER_19_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1925_ _1784_/C _1920_/Y _1922_/X _1924_/X VGND VGND VPWR VPWR _1926_/C sky130_fd_sc_hd__o2bb2a_1
X_1856_ _2193_/B _1457_/A _1784_/C _1765_/Y _1471_/A VGND VGND VPWR VPWR _1856_/X
+ sky130_fd_sc_hd__a32o_1
X_1787_ _1787_/A _1926_/B VGND VGND VPWR VPWR _1787_/X sky130_fd_sc_hd__or2_1
X_2339_ _2594_/B _2336_/X _2337_/Y _2338_/X VGND VGND VPWR VPWR _2339_/X sky130_fd_sc_hd__o22a_1
X_2408_ _2405_/X _2406_/Y _2407_/X _2415_/B VGND VGND VPWR VPWR _2408_/X sky130_fd_sc_hd__o31a_1
XFILLER_52_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1572_ _2633_/Q _1571_/X _1598_/S VGND VGND VPWR VPWR _2633_/D sky130_fd_sc_hd__mux2_1
X_1641_ _2821_/Q _2188_/A VGND VGND VPWR VPWR _1641_/Y sky130_fd_sc_hd__nand2_1
X_1710_ _1841_/A _2162_/B VGND VGND VPWR VPWR _2126_/B sky130_fd_sc_hd__nor2_1
XANTENNA_3 i_wb_addr[1] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2690_ _2883_/CLK _2690_/D VGND VGND VPWR VPWR _2690_/Q sky130_fd_sc_hd__dfxtp_2
X_2124_ _1418_/A _2122_/S _2009_/A _2123_/B _1712_/B VGND VGND VPWR VPWR _2127_/C
+ sky130_fd_sc_hd__a221o_1
XTAP_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2055_ _2054_/X _2702_/Q _2064_/S VGND VGND VPWR VPWR _2056_/B sky130_fd_sc_hd__mux2_1
XFILLER_22_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1839_ _2090_/A _1839_/B VGND VGND VPWR VPWR _2614_/B sky130_fd_sc_hd__nor2_4
X_1908_ _1988_/A _2769_/Q _1908_/C VGND VGND VPWR VPWR _1908_/X sky130_fd_sc_hd__and3_1
X_2888_ _2895_/CLK _2888_/D VGND VGND VPWR VPWR _2888_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_57_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput84 _2804_/Q VGND VGND VPWR VPWR o_wb_data[21] sky130_fd_sc_hd__clkbuf_1
Xoutput95 _2854_/Q VGND VGND VPWR VPWR o_wb_data[31] sky130_fd_sc_hd__clkbuf_1
Xoutput73 _2800_/Q VGND VGND VPWR VPWR o_wb_data[11] sky130_fd_sc_hd__clkbuf_1
Xclkbuf_2_3__f_i_clk clkbuf_0_i_clk/X VGND VGND VPWR VPWR _2653_/CLK sky130_fd_sc_hd__clkbuf_16
Xoutput62 _2001_/C VGND VGND VPWR VPWR o_qspi_cs_n sky130_fd_sc_hd__clkbuf_1
XFILLER_56_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2742_ _2742_/CLK _2742_/D VGND VGND VPWR VPWR _2742_/Q sky130_fd_sc_hd__dfxtp_2
XFILLER_31_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2811_ _2893_/CLK _2811_/D VGND VGND VPWR VPWR _2811_/Q sky130_fd_sc_hd__dfxtp_4
X_1555_ _2624_/Q _2621_/Q _2399_/S VGND VGND VPWR VPWR _1555_/X sky130_fd_sc_hd__mux2_1
X_2673_ _2683_/CLK _2673_/D VGND VGND VPWR VPWR _2673_/Q sky130_fd_sc_hd__dfxtp_1
X_1624_ _1690_/A _1838_/B VGND VGND VPWR VPWR _2180_/B sky130_fd_sc_hd__or2_2
XTAP_132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1486_ input5/X _2716_/Q VGND VGND VPWR VPWR _1486_/X sky130_fd_sc_hd__xor2_1
XTAP_165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2107_ _2721_/Q _1461_/A _2121_/S VGND VGND VPWR VPWR _2721_/D sky130_fd_sc_hd__mux2_1
XFILLER_54_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2038_ _2029_/Y _2693_/Q _2694_/Q _2032_/Y VGND VGND VPWR VPWR _2038_/Y sky130_fd_sc_hd__a22oi_1
XFILLER_22_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1340_ _2737_/Q VGND VGND VPWR VPWR _1363_/B sky130_fd_sc_hd__clkinv_2
XFILLER_36_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2725_ _2730_/CLK _2725_/D VGND VGND VPWR VPWR _2725_/Q sky130_fd_sc_hd__dfxtp_1
X_2656_ _2893_/CLK _2656_/D VGND VGND VPWR VPWR _2656_/Q sky130_fd_sc_hd__dfxtp_1
X_1607_ _2650_/Q _2647_/Q _2818_/Q VGND VGND VPWR VPWR _1607_/X sky130_fd_sc_hd__mux2_1
X_1469_ _1469_/A _1469_/B VGND VGND VPWR VPWR _1470_/B sky130_fd_sc_hd__or2_1
X_1538_ _2205_/B _1538_/B _2018_/B _1538_/D VGND VGND VPWR VPWR _1538_/X sky130_fd_sc_hd__or4_1
X_2587_ _2592_/B _2587_/B VGND VGND VPWR VPWR _2587_/Y sky130_fd_sc_hd__nand2_1
XFILLER_27_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2510_ _2875_/Q _2423_/X _2507_/X _2509_/X VGND VGND VPWR VPWR _2875_/D sky130_fd_sc_hd__o22a_1
X_2372_ _2826_/Q _1555_/X _2819_/D VGND VGND VPWR VPWR _2826_/D sky130_fd_sc_hd__mux2_1
X_2441_ _2562_/A _2594_/B _2441_/C VGND VGND VPWR VPWR _2441_/X sky130_fd_sc_hd__and3_1
X_1323_ _2738_/Q _2814_/Q VGND VGND VPWR VPWR _1323_/X sky130_fd_sc_hd__and2b_1
XFILLER_64_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2639_ _2853_/CLK _2639_/D VGND VGND VPWR VPWR _2639_/Q sky130_fd_sc_hd__dfxtp_1
X_2708_ _2748_/CLK _2708_/D VGND VGND VPWR VPWR _2708_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_58_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1872_ _2193_/B _1505_/A _1784_/C _1765_/Y input6/X VGND VGND VPWR VPWR _1872_/X
+ sky130_fd_sc_hd__a32o_1
X_1941_ _2716_/Q _1941_/B VGND VGND VPWR VPWR _1941_/Y sky130_fd_sc_hd__nor2_1
XFILLER_0_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2286_ _2285_/X _2784_/Q _2292_/S VGND VGND VPWR VPWR _2784_/D sky130_fd_sc_hd__mux2_1
X_1306_ _2855_/Q VGND VGND VPWR VPWR _2323_/B sky130_fd_sc_hd__inv_2
X_2424_ _2571_/A _2594_/B VGND VGND VPWR VPWR _2424_/Y sky130_fd_sc_hd__nor2_1
X_2355_ _2410_/A _2415_/B VGND VGND VPWR VPWR _2355_/Y sky130_fd_sc_hd__nor2_1
XFILLER_64_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2140_ _2819_/Q _2690_/Q _2689_/Q _2272_/B VGND VGND VPWR VPWR _2140_/X sky130_fd_sc_hd__a31o_1
XFILLER_34_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2071_ _2707_/Q _2072_/C _2708_/Q VGND VGND VPWR VPWR _2073_/B sky130_fd_sc_hd__o21a_1
X_1924_ _1457_/A _1765_/Y _1923_/X _1698_/A _2262_/B VGND VGND VPWR VPWR _1924_/X
+ sky130_fd_sc_hd__a221o_1
X_1855_ _2674_/Q _1742_/B _1854_/X _1982_/S VGND VGND VPWR VPWR _2674_/D sky130_fd_sc_hd__a22o_1
XFILLER_39_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1786_ _2665_/Q _1785_/X _1982_/S VGND VGND VPWR VPWR _2665_/D sky130_fd_sc_hd__mux2_1
X_2269_ _2193_/A _2193_/B _1731_/C _2016_/S _2264_/A VGND VGND VPWR VPWR _2270_/C
+ sky130_fd_sc_hd__a311o_1
XFILLER_29_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2407_ _2811_/Q _2894_/Q _2890_/Q VGND VGND VPWR VPWR _2407_/X sky130_fd_sc_hd__mux2_1
X_2338_ _2688_/Q _2685_/Q _2561_/S VGND VGND VPWR VPWR _2338_/X sky130_fd_sc_hd__mux2_1
XFILLER_37_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1571_ _2632_/Q _2629_/Q _2399_/S VGND VGND VPWR VPWR _1571_/X sky130_fd_sc_hd__mux2_1
XTAP_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1640_ _2090_/A _1640_/B VGND VGND VPWR VPWR _2188_/A sky130_fd_sc_hd__nor2_4
XFILLER_6_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_4 i_wb_addr[3] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2123_ _2123_/A _2123_/B VGND VGND VPWR VPWR _2127_/B sky130_fd_sc_hd__nor2_1
XTAP_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2054_ _2746_/Q _2824_/Q _2615_/B VGND VGND VPWR VPWR _2054_/X sky130_fd_sc_hd__mux2_1
XFILLER_22_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1838_ _1838_/A _1838_/B VGND VGND VPWR VPWR _1839_/B sky130_fd_sc_hd__or2_1
X_1907_ _2681_/Q _1906_/X _1982_/S VGND VGND VPWR VPWR _2681_/D sky130_fd_sc_hd__mux2_1
X_2887_ _2889_/CLK _2887_/D VGND VGND VPWR VPWR _2887_/Q sky130_fd_sc_hd__dfxtp_1
X_1769_ _2662_/Q _1742_/B _1768_/X _1982_/S VGND VGND VPWR VPWR _2662_/D sky130_fd_sc_hd__a22o_1
XFILLER_57_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_155 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput74 _2801_/Q VGND VGND VPWR VPWR o_wb_data[12] sky130_fd_sc_hd__clkbuf_1
Xoutput85 _2805_/Q VGND VGND VPWR VPWR o_wb_data[22] sky130_fd_sc_hd__clkbuf_1
Xoutput96 _2792_/Q VGND VGND VPWR VPWR o_wb_data[3] sky130_fd_sc_hd__clkbuf_1
XFILLER_48_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput63 _1321_/X VGND VGND VPWR VPWR o_qspi_dat[0] sky130_fd_sc_hd__clkbuf_1
XFILLER_0_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2741_ _2742_/CLK _2741_/D VGND VGND VPWR VPWR _2741_/Q sky130_fd_sc_hd__dfxtp_2
X_2810_ _2893_/CLK _2810_/D VGND VGND VPWR VPWR _2810_/Q sky130_fd_sc_hd__dfxtp_1
X_2672_ _2724_/CLK _2672_/D VGND VGND VPWR VPWR _2672_/Q sky130_fd_sc_hd__dfxtp_1
X_1554_ _2624_/Q _1553_/X _1598_/S VGND VGND VPWR VPWR _2624_/D sky130_fd_sc_hd__mux2_1
X_1623_ _2304_/B _1698_/C _1623_/C _2270_/B VGND VGND VPWR VPWR _1636_/B sky130_fd_sc_hd__or4b_1
X_1485_ _1488_/B _1484_/C _1759_/B VGND VGND VPWR VPWR _1485_/Y sky130_fd_sc_hd__a21oi_1
XTAP_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
.ends
