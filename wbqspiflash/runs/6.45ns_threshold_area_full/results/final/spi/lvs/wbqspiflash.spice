* NGSPICE file created from wbqspiflash.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VGND VPWR VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_1 abstract view
.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_4 abstract view
.subckt sky130_fd_sc_hd__dfxtp_4 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_8 abstract view
.subckt sky130_fd_sc_hd__nand2_8 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_2 abstract view
.subckt sky130_fd_sc_hd__clkinv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311oi_1 abstract view
.subckt sky130_fd_sc_hd__a311oi_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_1 abstract view
.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_1 abstract view
.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_1 abstract view
.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_1 abstract view
.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_1 abstract view
.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_1 abstract view
.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_1 abstract view
.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_8 abstract view
.subckt sky130_fd_sc_hd__nor2_8 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_1 abstract view
.subckt sky130_fd_sc_hd__a221oi_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_8 abstract view
.subckt sky130_fd_sc_hd__clkinv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_1 abstract view
.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111oi_1 abstract view
.subckt sky130_fd_sc_hd__a2111oi_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_1 abstract view
.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o41a_1 abstract view
.subckt sky130_fd_sc_hd__o41a_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_12 abstract view
.subckt sky130_fd_sc_hd__buf_12 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_1 abstract view
.subckt sky130_fd_sc_hd__o2111ai_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_2 abstract view
.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_4 abstract view
.subckt sky130_fd_sc_hd__inv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_1 abstract view
.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_16 abstract view
.subckt sky130_fd_sc_hd__inv_16 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_2 abstract view
.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_1 abstract view
.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_1 abstract view
.subckt sky130_fd_sc_hd__nor2b_1 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_8 abstract view
.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_1 abstract view
.subckt sky130_fd_sc_hd__nor3b_1 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_6 abstract view
.subckt sky130_fd_sc_hd__inv_6 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2ai_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2ai_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_1 abstract view
.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_2 abstract view
.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_8 abstract view
.subckt sky130_fd_sc_hd__inv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_2 abstract view
.subckt sky130_fd_sc_hd__a311o_2 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_2 abstract view
.subckt sky130_fd_sc_hd__and4_2 A B C D VGND VNB VPB VPWR X
.ends

.subckt wbqspiflash VGND VPWR i_clk i_qspi_dat[0] i_qspi_dat[1] i_qspi_dat[2] i_qspi_dat[3]
+ i_wb_addr[0] i_wb_addr[10] i_wb_addr[11] i_wb_addr[12] i_wb_addr[13] i_wb_addr[14]
+ i_wb_addr[15] i_wb_addr[16] i_wb_addr[17] i_wb_addr[18] i_wb_addr[19] i_wb_addr[1]
+ i_wb_addr[2] i_wb_addr[3] i_wb_addr[4] i_wb_addr[5] i_wb_addr[6] i_wb_addr[7] i_wb_addr[8]
+ i_wb_addr[9] i_wb_ctrl_stb i_wb_cyc i_wb_data[0] i_wb_data[10] i_wb_data[11] i_wb_data[12]
+ i_wb_data[13] i_wb_data[14] i_wb_data[15] i_wb_data[16] i_wb_data[17] i_wb_data[18]
+ i_wb_data[19] i_wb_data[1] i_wb_data[20] i_wb_data[21] i_wb_data[22] i_wb_data[23]
+ i_wb_data[24] i_wb_data[25] i_wb_data[26] i_wb_data[27] i_wb_data[28] i_wb_data[29]
+ i_wb_data[2] i_wb_data[30] i_wb_data[31] i_wb_data[3] i_wb_data[4] i_wb_data[5]
+ i_wb_data[6] i_wb_data[7] i_wb_data[8] i_wb_data[9] i_wb_data_stb i_wb_we o_interrupt
+ o_qspi_cs_n o_qspi_dat[0] o_qspi_dat[1] o_qspi_dat[2] o_qspi_dat[3] o_qspi_mod[0]
+ o_qspi_mod[1] o_qspi_sck o_wb_ack o_wb_data[0] o_wb_data[10] o_wb_data[11] o_wb_data[12]
+ o_wb_data[13] o_wb_data[14] o_wb_data[15] o_wb_data[16] o_wb_data[17] o_wb_data[18]
+ o_wb_data[19] o_wb_data[1] o_wb_data[20] o_wb_data[21] o_wb_data[22] o_wb_data[23]
+ o_wb_data[24] o_wb_data[25] o_wb_data[26] o_wb_data[27] o_wb_data[28] o_wb_data[29]
+ o_wb_data[2] o_wb_data[30] o_wb_data[31] o_wb_data[3] o_wb_data[4] o_wb_data[5]
+ o_wb_data[6] o_wb_data[7] o_wb_data[8] o_wb_data[9] o_wb_stall
XTAP_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3155_ input31/X _3765_/Q _3165_/S VGND VGND VPWR VPWR _3765_/D sky130_fd_sc_hd__mux2_1
XFILLER_39_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3086_ _3141_/S _3747_/Q _2941_/A VGND VGND VPWR VPWR _3087_/B sky130_fd_sc_hd__a21oi_1
XFILLER_54_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2106_ _2106_/A _2106_/B VGND VGND VPWR VPWR _2107_/D sky130_fd_sc_hd__nor2_1
X_2037_ _2037_/A _2549_/B VGND VGND VPWR VPWR _2040_/A sky130_fd_sc_hd__nand2_1
XFILLER_54_269 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2939_ _2940_/B _2940_/A VGND VGND VPWR VPWR _2941_/B sky130_fd_sc_hd__nor2_1
XFILLER_22_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_258 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3842_ _3842_/CLK _3842_/D VGND VGND VPWR VPWR _3842_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_32_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3773_ _3774_/CLK _3773_/D VGND VGND VPWR VPWR _3773_/Q sky130_fd_sc_hd__dfxtp_1
X_2724_ _2724_/A VGND VGND VPWR VPWR _2724_/Y sky130_fd_sc_hd__inv_2
X_2655_ _2655_/A _2668_/B _2721_/B VGND VGND VPWR VPWR _2655_/X sky130_fd_sc_hd__or3_1
X_2586_ _3474_/B _2559_/Y _2585_/Y VGND VGND VPWR VPWR _3679_/D sky130_fd_sc_hd__o21ai_1
XFILLER_67_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3207_ _3207_/A _3207_/B VGND VGND VPWR VPWR _3366_/S sky130_fd_sc_hd__nand2_4
XFILLER_82_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3138_ _3091_/X _3138_/B _3138_/C VGND VGND VPWR VPWR _3138_/Y sky130_fd_sc_hd__nand3b_1
X_3069_ _3204_/A _3068_/B _2820_/B VGND VGND VPWR VPWR _3069_/Y sky130_fd_sc_hd__a21oi_1
XFILLER_27_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_236 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2440_ _1880_/Y _3190_/B _2438_/Y _2439_/X VGND VGND VPWR VPWR _2820_/C sky130_fd_sc_hd__a31o_1
X_2371_ _2371_/A VGND VGND VPWR VPWR _2833_/B sky130_fd_sc_hd__inv_2
XFILLER_78_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3825_ _3901_/CLK _3825_/D VGND VGND VPWR VPWR _3825_/Q sky130_fd_sc_hd__dfxtp_1
X_3756_ _3759_/CLK _3756_/D VGND VGND VPWR VPWR _3756_/Q sky130_fd_sc_hd__dfxtp_4
X_2707_ _2839_/A _2435_/A _3689_/Q _2175_/A _2720_/B VGND VGND VPWR VPWR _2708_/A
+ sky130_fd_sc_hd__a32o_1
X_3687_ _3687_/CLK _3687_/D VGND VGND VPWR VPWR _3687_/Q sky130_fd_sc_hd__dfxtp_1
X_2638_ _2638_/A _2668_/B _2721_/B VGND VGND VPWR VPWR _2638_/X sky130_fd_sc_hd__or3_1
X_2569_ _2569_/A _3122_/B VGND VGND VPWR VPWR _2569_/Y sky130_fd_sc_hd__nand2_1
XFILLER_74_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_272 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1940_ _2113_/A _2187_/B VGND VGND VPWR VPWR _3131_/B sky130_fd_sc_hd__nand2_8
X_1871_ _3750_/Q _3749_/Q VGND VGND VPWR VPWR _2439_/B sky130_fd_sc_hd__nor2_2
X_3610_ _3902_/Q _3615_/A VGND VGND VPWR VPWR _3611_/B sky130_fd_sc_hd__or2_1
X_3541_ _3556_/A _3687_/Q _3540_/X _3406_/Y VGND VGND VPWR VPWR _3541_/X sky130_fd_sc_hd__a211o_1
X_3472_ _3474_/B _3553_/A _3411_/A VGND VGND VPWR VPWR _3472_/Y sky130_fd_sc_hd__a21oi_1
XFILLER_50_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2423_ _2821_/A _2423_/B VGND VGND VPWR VPWR _2423_/Y sky130_fd_sc_hd__nand2_1
X_2354_ _2943_/B _2943_/A VGND VGND VPWR VPWR _2355_/B sky130_fd_sc_hd__nand2_1
X_2285_ _2285_/A _3190_/B VGND VGND VPWR VPWR _2286_/A sky130_fd_sc_hd__nand2_1
XFILLER_52_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_150 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3808_ _3842_/CLK _3808_/D VGND VGND VPWR VPWR _3808_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_20_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3739_ _3860_/CLK _3739_/D VGND VGND VPWR VPWR _3739_/Q sky130_fd_sc_hd__dfxtp_2
XFILLER_47_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_106 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2070_ _3740_/Q VGND VGND VPWR VPWR _2883_/A sky130_fd_sc_hd__clkinv_2
XFILLER_19_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_183 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2972_ _3002_/A _3729_/Q VGND VGND VPWR VPWR _2972_/Y sky130_fd_sc_hd__nand2_1
XFILLER_61_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1923_ _3747_/Q _3748_/Q VGND VGND VPWR VPWR _1928_/A sky130_fd_sc_hd__and2b_1
X_1854_ _2140_/A _2259_/B VGND VGND VPWR VPWR _1916_/A sky130_fd_sc_hd__and2_1
X_3524_ _3887_/Q _3884_/Q _3607_/A VGND VGND VPWR VPWR _3525_/B sky130_fd_sc_hd__mux2_1
X_3455_ _3451_/X _3453_/X _3454_/X _3876_/Q _3577_/A VGND VGND VPWR VPWR _3876_/D
+ sky130_fd_sc_hd__a32o_1
X_2406_ _3752_/Q _2782_/A _2405_/C _2608_/A _2405_/X VGND VGND VPWR VPWR _2406_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_69_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3386_ _3279_/B _3291_/B _1835_/B _1825_/B VGND VGND VPWR VPWR _3386_/X sky130_fd_sc_hd__a22o_1
X_2337_ _2337_/A _2337_/B VGND VGND VPWR VPWR _2337_/Y sky130_fd_sc_hd__nand2_1
XFILLER_57_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2268_ _2268_/A VGND VGND VPWR VPWR _2948_/B sky130_fd_sc_hd__inv_2
XFILLER_37_150 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2199_ _3630_/Q input3/X _3362_/S VGND VGND VPWR VPWR _2199_/X sky130_fd_sc_hd__mux2_1
XFILLER_25_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_304 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_56 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_5 _3628_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3240_ _3244_/A _3835_/Q _3244_/C VGND VGND VPWR VPWR _3240_/X sky130_fd_sc_hd__and3_1
XFILLER_3_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3171_ input48/X _3781_/Q _3173_/S VGND VGND VPWR VPWR _3781_/D sky130_fd_sc_hd__mux2_1
XTAP_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_223 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2122_ _2122_/A _2439_/B VGND VGND VPWR VPWR _2184_/A sky130_fd_sc_hd__and2_1
XFILLER_81_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2053_ _2053_/A _2053_/B _2053_/C VGND VGND VPWR VPWR _2054_/B sky130_fd_sc_hd__nand3_1
XFILLER_62_462 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2955_ _2367_/A _3023_/A _2399_/A _2286_/A _2303_/X VGND VGND VPWR VPWR _3017_/A
+ sky130_fd_sc_hd__a311oi_1
X_1906_ _3011_/B _3060_/B VGND VGND VPWR VPWR _1915_/A sky130_fd_sc_hd__nor2_1
X_2886_ _2886_/A _2886_/B _2886_/C _2886_/D VGND VGND VPWR VPWR _2886_/X sky130_fd_sc_hd__and4_1
X_1837_ _3306_/A _1828_/Y _3662_/Q _1830_/X _3579_/A VGND VGND VPWR VPWR _1838_/A
+ sky130_fd_sc_hd__a311o_1
X_3507_ _3568_/A _3507_/B VGND VGND VPWR VPWR _3507_/X sky130_fd_sc_hd__or2_1
X_3438_ _3559_/A _3438_/B VGND VGND VPWR VPWR _3438_/Y sky130_fd_sc_hd__nor2_1
XTAP_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3369_ _3367_/X _3368_/Y _3319_/A VGND VGND VPWR VPWR _3369_/Y sky130_fd_sc_hd__a21oi_1
XTAP_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_16 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput75 _3810_/Q VGND VGND VPWR VPWR o_wb_data[13] sky130_fd_sc_hd__clkbuf_1
Xoutput64 _1845_/X VGND VGND VPWR VPWR o_qspi_dat[1] sky130_fd_sc_hd__clkbuf_1
Xoutput86 _3814_/Q VGND VGND VPWR VPWR o_wb_data[23] sky130_fd_sc_hd__clkbuf_1
Xoutput97 _3801_/Q VGND VGND VPWR VPWR o_wb_data[4] sky130_fd_sc_hd__clkbuf_1
XFILLER_48_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_267 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2740_ _2883_/A _3011_/A _3046_/B _2737_/Y _2739_/X VGND VGND VPWR VPWR _2740_/X
+ sky130_fd_sc_hd__o2111a_1
XFILLER_8_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2671_ _3685_/Q _2762_/B _2839_/A _2670_/Y VGND VGND VPWR VPWR _2672_/A sky130_fd_sc_hd__a31o_1
X_3223_ _3222_/X _3794_/Q _3263_/S VGND VGND VPWR VPWR _3794_/D sky130_fd_sc_hd__mux2_1
XTAP_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3154_ input30/X _3764_/Q _3165_/S VGND VGND VPWR VPWR _3764_/D sky130_fd_sc_hd__mux2_1
XFILLER_39_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3085_ _3085_/A _3085_/B VGND VGND VPWR VPWR _3087_/A sky130_fd_sc_hd__nand2_1
XFILLER_39_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2105_ _2105_/A _2105_/B _2105_/C VGND VGND VPWR VPWR _2106_/B sky130_fd_sc_hd__or3_1
X_2036_ _2039_/A _2042_/A VGND VGND VPWR VPWR _2037_/A sky130_fd_sc_hd__nand2_1
XFILLER_54_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_432 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_318 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2938_ _3720_/Q VGND VGND VPWR VPWR _2940_/B sky130_fd_sc_hd__inv_2
X_2869_ _3702_/Q VGND VGND VPWR VPWR _2879_/A sky130_fd_sc_hd__inv_2
XTAP_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_410 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_207 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3841_ _3842_/CLK _3841_/D VGND VGND VPWR VPWR _3841_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_80_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3772_ _3774_/CLK _3772_/D VGND VGND VPWR VPWR _3772_/Q sky130_fd_sc_hd__dfxtp_1
X_2723_ _2723_/A _2788_/B VGND VGND VPWR VPWR _2724_/A sky130_fd_sc_hd__nor2_1
X_2654_ _2654_/A VGND VGND VPWR VPWR _2655_/A sky130_fd_sc_hd__inv_2
X_2585_ _2576_/X _2583_/X _2584_/Y VGND VGND VPWR VPWR _2585_/Y sky130_fd_sc_hd__o21ai_1
X_3206_ _3204_/X _3206_/B _3206_/C _3206_/D VGND VGND VPWR VPWR _3207_/B sky130_fd_sc_hd__and4b_1
XFILLER_67_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3137_ _3011_/B _3136_/Y _3049_/B VGND VGND VPWR VPWR _3137_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_82_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3068_ _3601_/A _3068_/B VGND VGND VPWR VPWR _3068_/Y sky130_fd_sc_hd__nor2_1
X_2019_ _2019_/A _2019_/B _2019_/C VGND VGND VPWR VPWR _2030_/A sky130_fd_sc_hd__nand3_1
XFILLER_23_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_74 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2370_ _3054_/B _2370_/B VGND VGND VPWR VPWR _2370_/Y sky130_fd_sc_hd__nand2_1
XFILLER_1_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3824_ _3865_/CLK _3824_/D VGND VGND VPWR VPWR _3824_/Q sky130_fd_sc_hd__dfxtp_1
X_3755_ _3759_/CLK _3755_/D VGND VGND VPWR VPWR _3755_/Q sky130_fd_sc_hd__dfxtp_4
X_2706_ _2705_/X _3688_/Q _2793_/A VGND VGND VPWR VPWR _3688_/D sky130_fd_sc_hd__mux2_1
X_3686_ _3736_/CLK _3686_/D VGND VGND VPWR VPWR _3686_/Q sky130_fd_sc_hd__dfxtp_1
X_2637_ _3498_/B _2796_/B _2564_/Y _2023_/B _3011_/A VGND VGND VPWR VPWR _2637_/X
+ sky130_fd_sc_hd__o32a_1
X_2568_ _2839_/A _2762_/B _3678_/Q input7/X _3121_/A VGND VGND VPWR VPWR _2569_/A
+ sky130_fd_sc_hd__a32o_1
XFILLER_58_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2499_ _2668_/B _2721_/B VGND VGND VPWR VPWR _3204_/B sky130_fd_sc_hd__nor2_2
XFILLER_55_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_446 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_295 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1870_ _1870_/A VGND VGND VPWR VPWR _2439_/C sky130_fd_sc_hd__buf_6
X_3540_ _3555_/A _3690_/Q VGND VGND VPWR VPWR _3540_/X sky130_fd_sc_hd__and2_1
XFILLER_6_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3471_ _3568_/A _3471_/B VGND VGND VPWR VPWR _3471_/X sky130_fd_sc_hd__or2_1
XFILLER_69_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2422_ _2749_/A _3119_/A _2419_/Y _2420_/Y _2421_/X VGND VGND VPWR VPWR _2821_/A
+ sky130_fd_sc_hd__a2111o_1
XFILLER_43_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2353_ _3722_/Q VGND VGND VPWR VPWR _2943_/A sky130_fd_sc_hd__inv_2
X_2284_ _3016_/B _2284_/B VGND VGND VPWR VPWR _2855_/D sky130_fd_sc_hd__nand2_1
XFILLER_37_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_162 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3807_ _3842_/CLK _3807_/D VGND VGND VPWR VPWR _3807_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_20_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1999_ _3729_/Q VGND VGND VPWR VPWR _2000_/B sky130_fd_sc_hd__inv_2
X_3738_ _3860_/CLK _3738_/D VGND VGND VPWR VPWR _3738_/Q sky130_fd_sc_hd__dfxtp_2
X_3669_ _3877_/CLK _3669_/D VGND VGND VPWR VPWR _3669_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_75_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_332 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_19_i_clk clkbuf_2_3__f_i_clk/X VGND VGND VPWR VPWR _3860_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_11_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_118 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_132 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2971_ _2051_/C _2960_/X _2970_/Y VGND VGND VPWR VPWR _3728_/D sky130_fd_sc_hd__o21ai_1
X_1922_ _2142_/B VGND VGND VPWR VPWR _2109_/B sky130_fd_sc_hd__inv_2
X_1853_ _1853_/A VGND VGND VPWR VPWR _2259_/B sky130_fd_sc_hd__inv_2
X_3523_ _3556_/A _3684_/Q _3522_/Y _3406_/Y VGND VGND VPWR VPWR _3523_/X sky130_fd_sc_hd__a211o_1
X_3454_ _3676_/Q _3606_/B _3390_/Y VGND VGND VPWR VPWR _3454_/X sky130_fd_sc_hd__o21a_1
X_2405_ _3122_/B _2762_/B _2405_/C VGND VGND VPWR VPWR _2405_/X sky130_fd_sc_hd__and3_1
X_3385_ _3384_/X _3864_/Q _3385_/S VGND VGND VPWR VPWR _3864_/D sky130_fd_sc_hd__mux2_1
XFILLER_69_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2336_ _2336_/A _3132_/B _3186_/A VGND VGND VPWR VPWR _2337_/B sky130_fd_sc_hd__and3_1
XFILLER_57_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2267_ _2391_/A _3032_/C VGND VGND VPWR VPWR _2268_/A sky130_fd_sc_hd__nand2_1
XFILLER_72_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2198_ _2197_/X _3630_/Q _2244_/S VGND VGND VPWR VPWR _3630_/D sky130_fd_sc_hd__mux2_1
XFILLER_80_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_338 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_162 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_6 _2540_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_68 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3170_ input47/X _3780_/Q _3173_/S VGND VGND VPWR VPWR _3780_/D sky130_fd_sc_hd__mux2_1
XFILLER_66_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2121_ _2713_/A _3056_/B _2752_/B _3090_/B _3023_/A VGND VGND VPWR VPWR _2132_/A
+ sky130_fd_sc_hd__a41o_1
X_2052_ _2052_/A _2566_/A VGND VGND VPWR VPWR _2053_/C sky130_fd_sc_hd__nand2_1
XFILLER_81_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2954_ _2954_/A _3203_/A _2954_/C _2954_/D VGND VGND VPWR VPWR _2956_/B sky130_fd_sc_hd__or4_1
X_1905_ _3056_/B VGND VGND VPWR VPWR _3060_/B sky130_fd_sc_hd__clkinv_2
X_2885_ _2885_/A _3704_/Q VGND VGND VPWR VPWR _2886_/D sky130_fd_sc_hd__nand2_1
X_1836_ _3381_/B VGND VGND VPWR VPWR _3579_/A sky130_fd_sc_hd__inv_2
X_3506_ _3884_/Q _3881_/Q _3552_/S VGND VGND VPWR VPWR _3507_/B sky130_fd_sc_hd__mux2_1
X_3437_ _3433_/X _3435_/X _3436_/Y _3873_/Q _3577_/A VGND VGND VPWR VPWR _3873_/D
+ sky130_fd_sc_hd__a32o_1
XTAP_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3368_ _3368_/A _3368_/B _3368_/C VGND VGND VPWR VPWR _3368_/Y sky130_fd_sc_hd__nand3_1
XTAP_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2319_ _2455_/A VGND VGND VPWR VPWR _2668_/B sky130_fd_sc_hd__inv_2
XFILLER_66_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3299_ _3306_/B _3820_/Q VGND VGND VPWR VPWR _3299_/Y sky130_fd_sc_hd__nand2_1
XFILLER_38_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_102 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput76 _3787_/Q VGND VGND VPWR VPWR o_wb_data[14] sky130_fd_sc_hd__clkbuf_1
Xoutput65 _1846_/X VGND VGND VPWR VPWR o_qspi_dat[2] sky130_fd_sc_hd__clkbuf_1
Xoutput87 _3815_/Q VGND VGND VPWR VPWR o_wb_data[24] sky130_fd_sc_hd__clkbuf_1
Xoutput98 _3802_/Q VGND VGND VPWR VPWR o_wb_data[5] sky130_fd_sc_hd__clkbuf_1
XFILLER_0_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_452 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2670_ _2670_/A VGND VGND VPWR VPWR _2670_/Y sky130_fd_sc_hd__inv_2
X_3222_ _3858_/Q _3270_/A _3229_/A _3101_/Y VGND VGND VPWR VPWR _3222_/X sky130_fd_sc_hd__a22o_1
XTAP_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3153_ input29/X _3763_/Q _3165_/S VGND VGND VPWR VPWR _3763_/D sky130_fd_sc_hd__mux2_1
X_2104_ _2104_/A _2104_/B VGND VGND VPWR VPWR _2105_/C sky130_fd_sc_hd__nand2_1
X_3084_ _3084_/A _3084_/B _3141_/S VGND VGND VPWR VPWR _3085_/B sky130_fd_sc_hd__nor3_1
X_2035_ _3724_/Q _3725_/Q _3726_/Q VGND VGND VPWR VPWR _2042_/A sky130_fd_sc_hd__nand3_1
XFILLER_50_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_455 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2937_ _3719_/Q _2935_/B _2936_/X VGND VGND VPWR VPWR _3719_/D sky130_fd_sc_hd__a21o_1
XFILLER_50_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2868_ _3701_/Q _2752_/B _2601_/Y VGND VGND VPWR VPWR _3701_/D sky130_fd_sc_hd__a21o_1
X_1819_ _3275_/B _3865_/Q VGND VGND VPWR VPWR _3368_/C sky130_fd_sc_hd__nand2_1
X_2799_ _3782_/Q _3058_/B _2842_/B VGND VGND VPWR VPWR _2800_/A sky130_fd_sc_hd__o21ai_1
XTAP_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_452 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3840_ _3842_/CLK _3840_/D VGND VGND VPWR VPWR _3840_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_32_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3771_ _3774_/CLK _3771_/D VGND VGND VPWR VPWR _3771_/Q sky130_fd_sc_hd__dfxtp_1
X_2722_ _2729_/A VGND VGND VPWR VPWR _2788_/B sky130_fd_sc_hd__inv_2
XFILLER_73_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2653_ _3504_/B _2796_/B _2564_/Y _2084_/A _3011_/A VGND VGND VPWR VPWR _2653_/X
+ sky130_fd_sc_hd__o32a_1
X_2584_ _3084_/A _2803_/S VGND VGND VPWR VPWR _2584_/Y sky130_fd_sc_hd__nor2_1
X_3205_ _3827_/Q _3053_/B _3203_/A _2381_/B _2301_/C VGND VGND VPWR VPWR _3206_/B
+ sky130_fd_sc_hd__a2111o_1
XFILLER_67_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3136_ _3101_/Y _2476_/A _2157_/Y VGND VGND VPWR VPWR _3136_/Y sky130_fd_sc_hd__a21oi_1
XFILLER_82_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3067_ _3067_/A _3067_/B VGND VGND VPWR VPWR _3068_/B sky130_fd_sc_hd__nand2_1
XFILLER_82_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2018_ _3119_/A _2169_/B _2749_/A VGND VGND VPWR VPWR _2019_/C sky130_fd_sc_hd__nand3_1
XFILLER_23_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_396 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3823_ _3903_/CLK _3823_/D VGND VGND VPWR VPWR _3823_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_32_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_296 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3754_ _3865_/CLK _3754_/D VGND VGND VPWR VPWR _3754_/Q sky130_fd_sc_hd__dfxtp_4
X_2705_ _2690_/Y _2700_/Y _2701_/Y _2704_/X VGND VGND VPWR VPWR _2705_/X sky130_fd_sc_hd__a211o_1
X_3685_ _3736_/CLK _3685_/D VGND VGND VPWR VPWR _3685_/Q sky130_fd_sc_hd__dfxtp_2
X_2636_ _2883_/A _2600_/Y _2635_/X VGND VGND VPWR VPWR _2636_/X sky130_fd_sc_hd__o21a_1
X_2567_ _2567_/A _2668_/B _2721_/B VGND VGND VPWR VPWR _2567_/X sky130_fd_sc_hd__or3_1
X_2498_ _2608_/A _3670_/Q _2839_/A VGND VGND VPWR VPWR _2498_/X sky130_fd_sc_hd__and3_1
XFILLER_74_108 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_82_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3119_ _3119_/A VGND VGND VPWR VPWR _3196_/B sky130_fd_sc_hd__inv_2
XFILLER_55_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_458 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3470_ _3878_/Q _3875_/Q _3552_/S VGND VGND VPWR VPWR _3471_/B sky130_fd_sc_hd__mux2_1
X_2421_ _2810_/B _3084_/A _3020_/A VGND VGND VPWR VPWR _2421_/X sky130_fd_sc_hd__or3_1
X_2352_ _2352_/A _2932_/A VGND VGND VPWR VPWR _2943_/B sky130_fd_sc_hd__nor2_1
XFILLER_69_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2283_ _3270_/A VGND VGND VPWR VPWR _2284_/B sky130_fd_sc_hd__inv_2
XFILLER_37_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3806_ _3842_/CLK _3806_/D VGND VGND VPWR VPWR _3806_/Q sky130_fd_sc_hd__dfxtp_1
X_1998_ _2083_/A _3728_/Q VGND VGND VPWR VPWR _2059_/B sky130_fd_sc_hd__nand2_1
X_3737_ _3737_/CLK _3737_/D VGND VGND VPWR VPWR _3737_/Q sky130_fd_sc_hd__dfxtp_2
X_3668_ _3890_/CLK _3668_/D VGND VGND VPWR VPWR _3668_/Q sky130_fd_sc_hd__dfxtp_1
X_3599_ _3376_/Y _3580_/Y _3598_/X VGND VGND VPWR VPWR _3900_/D sky130_fd_sc_hd__a21oi_1
X_2619_ _2619_/A _2618_/Y VGND VGND VPWR VPWR _2619_/X sky130_fd_sc_hd__or2b_1
XFILLER_75_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2970_ _3002_/A _3728_/Q VGND VGND VPWR VPWR _2970_/Y sky130_fd_sc_hd__nand2_1
X_1921_ _3094_/A _3009_/S _2949_/A VGND VGND VPWR VPWR _1921_/Y sky130_fd_sc_hd__o21ai_1
X_1852_ _3750_/Q _3749_/Q VGND VGND VPWR VPWR _1853_/A sky130_fd_sc_hd__nand2_1
X_3522_ _3559_/A _3522_/B VGND VGND VPWR VPWR _3522_/Y sky130_fd_sc_hd__nor2_1
X_3453_ _3568_/A _3453_/B VGND VGND VPWR VPWR _3453_/X sky130_fd_sc_hd__or2_1
XFILLER_6_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2404_ _3099_/B _3011_/B VGND VGND VPWR VPWR _2608_/A sky130_fd_sc_hd__nor2_8
X_3384_ _3384_/A _3314_/Y VGND VGND VPWR VPWR _3384_/X sky130_fd_sc_hd__or2b_1
XFILLER_69_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2335_ _2327_/X _2371_/A _2328_/Y _2373_/B _3072_/A VGND VGND VPWR VPWR _2336_/A
+ sky130_fd_sc_hd__a41o_1
X_2266_ _2266_/A VGND VGND VPWR VPWR _3138_/C sky130_fd_sc_hd__inv_2
XFILLER_37_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2197_ _3629_/Q input2/X _3362_/S VGND VGND VPWR VPWR _2197_/X sky130_fd_sc_hd__mux2_1
XFILLER_52_111 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_369 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_7 _2590_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2120_ _2120_/A _2185_/A VGND VGND VPWR VPWR _3090_/B sky130_fd_sc_hd__nand2_2
XFILLER_66_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2051_ _2059_/A _2059_/B _2051_/C VGND VGND VPWR VPWR _2053_/B sky130_fd_sc_hd__nand3_1
XFILLER_54_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2953_ _2953_/A _3204_/D _3118_/A VGND VGND VPWR VPWR _2954_/D sky130_fd_sc_hd__or3_1
X_1904_ _3094_/A _3067_/A VGND VGND VPWR VPWR _3056_/B sky130_fd_sc_hd__nor2_4
X_2884_ _2884_/A _3740_/Q VGND VGND VPWR VPWR _2886_/C sky130_fd_sc_hd__nand2_1
XFILLER_30_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1835_ _3553_/A _1835_/B VGND VGND VPWR VPWR _3381_/B sky130_fd_sc_hd__nand2_1
X_3505_ _3556_/A _3681_/Q _3504_/Y _3406_/Y VGND VGND VPWR VPWR _3505_/X sky130_fd_sc_hd__a211o_1
X_3436_ _3438_/B _3553_/A _3411_/A VGND VGND VPWR VPWR _3436_/Y sky130_fd_sc_hd__a21oi_1
XTAP_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3367_ _3662_/Q _3367_/B _3367_/C VGND VGND VPWR VPWR _3367_/X sky130_fd_sc_hd__or3_1
XTAP_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2318_ _2825_/A _2777_/A VGND VGND VPWR VPWR _2455_/A sky130_fd_sc_hd__nor2_2
X_3298_ _3820_/Q _1835_/B _3368_/B _3368_/C _3297_/X VGND VGND VPWR VPWR _3298_/Y
+ sky130_fd_sc_hd__a221oi_1
Xclkbuf_leaf_18_i_clk clkbuf_2_3__f_i_clk/X VGND VGND VPWR VPWR _3862_/CLK sky130_fd_sc_hd__clkbuf_16
X_2249_ _3655_/Q _3652_/Q _3826_/Q VGND VGND VPWR VPWR _2249_/X sky130_fd_sc_hd__mux2_1
XFILLER_38_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_420 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput66 _1847_/X VGND VGND VPWR VPWR o_qspi_dat[3] sky130_fd_sc_hd__clkbuf_1
Xoutput88 _3816_/Q VGND VGND VPWR VPWR o_wb_data[25] sky130_fd_sc_hd__clkbuf_1
Xoutput77 _3788_/Q VGND VGND VPWR VPWR o_wb_data[15] sky130_fd_sc_hd__clkbuf_1
Xoutput99 _3803_/Q VGND VGND VPWR VPWR o_wb_data[6] sky130_fd_sc_hd__clkbuf_1
XFILLER_56_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3221_ _3220_/X _3793_/Q _3263_/S VGND VGND VPWR VPWR _3793_/D sky130_fd_sc_hd__mux2_1
XTAP_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3152_ input28/X _3762_/Q _3165_/S VGND VGND VPWR VPWR _3762_/D sky130_fd_sc_hd__mux2_1
X_2103_ _2103_/A _2103_/B _2103_/C VGND VGND VPWR VPWR _2107_/C sky130_fd_sc_hd__and3_1
X_3083_ _3083_/A _3083_/B VGND VGND VPWR VPWR _3141_/S sky130_fd_sc_hd__nand2_4
X_2034_ _2749_/A _2034_/B VGND VGND VPWR VPWR _2039_/A sky130_fd_sc_hd__nand2_1
XFILLER_22_114 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2936_ _2941_/A _2940_/A VGND VGND VPWR VPWR _2936_/X sky130_fd_sc_hd__or2_1
X_2867_ _3700_/Q _2861_/Y _2867_/S VGND VGND VPWR VPWR _3700_/D sky130_fd_sc_hd__mux2_1
X_1818_ _3864_/Q _3863_/Q VGND VGND VPWR VPWR _3275_/B sky130_fd_sc_hd__nor2_2
X_2798_ _2798_/A _2798_/B VGND VGND VPWR VPWR _2798_/Y sky130_fd_sc_hd__nor2_1
XFILLER_77_18 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3419_ _3415_/X _3417_/X _3418_/X _3870_/Q _3577_/A VGND VGND VPWR VPWR _3870_/D
+ sky130_fd_sc_hd__a32o_1
XTAP_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_464 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_434 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3770_ _3774_/CLK _3770_/D VGND VGND VPWR VPWR _3770_/Q sky130_fd_sc_hd__dfxtp_1
X_2721_ _2721_/A _2721_/B VGND VGND VPWR VPWR _2721_/Y sky130_fd_sc_hd__nor2_1
XFILLER_8_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2652_ _2885_/A _2600_/Y _2651_/X VGND VGND VPWR VPWR _2652_/X sky130_fd_sc_hd__o21a_1
XFILLER_66_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2583_ _3679_/Q _2839_/A _2608_/A _2577_/X _2582_/X VGND VGND VPWR VPWR _2583_/X
+ sky130_fd_sc_hd__a311o_1
X_3204_ _3204_/A _3204_/B _3204_/C _3204_/D VGND VGND VPWR VPWR _3204_/X sky130_fd_sc_hd__or4_1
X_3135_ _3127_/X _3133_/Y _3134_/X VGND VGND VPWR VPWR _3750_/D sky130_fd_sc_hd__a21oi_1
XFILLER_27_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3066_ _3698_/Q _3697_/Q VGND VGND VPWR VPWR _3601_/A sky130_fd_sc_hd__nand2_1
X_2017_ _2540_/B VGND VGND VPWR VPWR _2169_/B sky130_fd_sc_hd__inv_2
XFILLER_42_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2919_ _3714_/Q _3022_/A VGND VGND VPWR VPWR _2924_/A sky130_fd_sc_hd__or2_1
X_3899_ _3900_/CLK _3899_/D VGND VGND VPWR VPWR _3899_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_12_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_323 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3822_ _3903_/CLK _3822_/D VGND VGND VPWR VPWR _3822_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_32_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3753_ _3865_/CLK _3753_/D VGND VGND VPWR VPWR _3753_/Q sky130_fd_sc_hd__dfxtp_2
X_2704_ _3737_/Q _2856_/B _2608_/A _2700_/Y _2703_/X VGND VGND VPWR VPWR _2704_/X
+ sky130_fd_sc_hd__a221o_1
X_3684_ _3736_/CLK _3684_/D VGND VGND VPWR VPWR _3684_/Q sky130_fd_sc_hd__dfxtp_1
X_2635_ _2883_/A _2842_/C _2633_/X _2371_/A _2634_/Y VGND VGND VPWR VPWR _2635_/X
+ sky130_fd_sc_hd__a221o_1
X_2566_ _2566_/A VGND VGND VPWR VPWR _2567_/A sky130_fd_sc_hd__inv_2
X_2497_ _2839_/A _2762_/B _3670_/Q _2566_/A _3121_/A VGND VGND VPWR VPWR _2497_/X
+ sky130_fd_sc_hd__a32o_1
XFILLER_4_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3118_ _3118_/A _3555_/A VGND VGND VPWR VPWR _3118_/Y sky130_fd_sc_hd__nand2_1
XFILLER_82_175 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3049_ _3049_/A _3049_/B VGND VGND VPWR VPWR _3085_/A sky130_fd_sc_hd__nand2_1
XFILLER_55_378 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_348 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2420_ _3056_/B _2749_/A VGND VGND VPWR VPWR _2420_/Y sky130_fd_sc_hd__nand2_1
XFILLER_69_415 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2351_ _3718_/Q _2930_/A VGND VGND VPWR VPWR _2932_/A sky130_fd_sc_hd__or2_1
X_2282_ _3131_/B _2949_/A VGND VGND VPWR VPWR _3270_/A sky130_fd_sc_hd__nand2_8
XFILLER_49_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_223 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3805_ _3838_/CLK _3805_/D VGND VGND VPWR VPWR _3805_/Q sky130_fd_sc_hd__dfxtp_1
X_1997_ _1983_/Y _1997_/B _1997_/C VGND VGND VPWR VPWR _2099_/A sky130_fd_sc_hd__nand3b_1
X_3736_ _3736_/CLK _3736_/D VGND VGND VPWR VPWR _3736_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_69_19 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3667_ _3897_/CLK _3667_/D VGND VGND VPWR VPWR _3667_/Q sky130_fd_sc_hd__dfxtp_1
X_3598_ _2838_/Y _3406_/Y _3568_/A _3595_/X _3597_/Y VGND VGND VPWR VPWR _3598_/X
+ sky130_fd_sc_hd__o221a_1
X_2618_ _2876_/S _3767_/Q VGND VGND VPWR VPWR _2618_/Y sky130_fd_sc_hd__nand2_1
X_2549_ _2863_/A _2549_/B _3121_/A VGND VGND VPWR VPWR _2556_/A sky130_fd_sc_hd__and3_1
XFILLER_75_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_201 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_54 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1920_ _2120_/A _2187_/B VGND VGND VPWR VPWR _2949_/A sky130_fd_sc_hd__nand2_8
X_1851_ _3748_/Q _3036_/A VGND VGND VPWR VPWR _2140_/A sky130_fd_sc_hd__nor2_1
X_3521_ _3517_/X _3519_/X _3520_/Y _3887_/Q _3577_/A VGND VGND VPWR VPWR _3887_/D
+ sky130_fd_sc_hd__a32o_1
X_3452_ _3875_/Q _3872_/Q _3552_/S VGND VGND VPWR VPWR _3453_/B sky130_fd_sc_hd__mux2_1
X_3383_ _3369_/Y _3863_/Q _3385_/S VGND VGND VPWR VPWR _3863_/D sky130_fd_sc_hd__mux2_1
X_2403_ _2403_/A _2796_/B VGND VGND VPWR VPWR _2405_/C sky130_fd_sc_hd__nor2_1
XFILLER_69_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2334_ _3067_/B _2832_/B VGND VGND VPWR VPWR _3072_/A sky130_fd_sc_hd__nor2_2
X_2265_ _2371_/A _3056_/A VGND VGND VPWR VPWR _2266_/A sky130_fd_sc_hd__nand2_1
X_2196_ _2193_/X _3629_/Q _2244_/S VGND VGND VPWR VPWR _3629_/D sky130_fd_sc_hd__mux2_1
XFILLER_25_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_145 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_178 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3719_ _3759_/CLK _3719_/D VGND VGND VPWR VPWR _3719_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_20_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_8 _2647_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2050_ _2577_/B VGND VGND VPWR VPWR _2051_/C sky130_fd_sc_hd__inv_2
XFILLER_19_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2952_ _2952_/A VGND VGND VPWR VPWR _3118_/A sky130_fd_sc_hd__inv_2
X_1903_ _1903_/A VGND VGND VPWR VPWR _3067_/A sky130_fd_sc_hd__clkinv_2
X_2883_ _2883_/A _3703_/Q VGND VGND VPWR VPWR _2886_/B sky130_fd_sc_hd__nand2_1
X_1834_ _3367_/B VGND VGND VPWR VPWR _1835_/B sky130_fd_sc_hd__inv_2
X_3504_ _3559_/A _3504_/B VGND VGND VPWR VPWR _3504_/Y sky130_fd_sc_hd__nor2_1
X_3435_ _3568_/A _3435_/B VGND VGND VPWR VPWR _3435_/X sky130_fd_sc_hd__or2_1
XTAP_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3366_ _3365_/X _3862_/Q _3366_/S VGND VGND VPWR VPWR _3862_/D sky130_fd_sc_hd__mux2_1
XTAP_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3297_ _3559_/A _3696_/Q _3296_/Y _3367_/B VGND VGND VPWR VPWR _3297_/X sky130_fd_sc_hd__o211a_1
X_2317_ _2435_/A VGND VGND VPWR VPWR _2777_/A sky130_fd_sc_hd__clkinv_2
X_2248_ _2247_/X _3655_/Q _3327_/B VGND VGND VPWR VPWR _3655_/D sky130_fd_sc_hd__mux2_1
X_2179_ _2439_/A _2179_/B VGND VGND VPWR VPWR _2179_/X sky130_fd_sc_hd__or2_1
XFILLER_53_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_24 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput67 _1840_/X VGND VGND VPWR VPWR o_qspi_mod[0] sky130_fd_sc_hd__clkbuf_1
Xoutput89 _3817_/Q VGND VGND VPWR VPWR o_wb_data[26] sky130_fd_sc_hd__clkbuf_1
Xoutput78 _3789_/Q VGND VGND VPWR VPWR o_wb_data[16] sky130_fd_sc_hd__clkbuf_1
XFILLER_48_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3220_ _3857_/Q _3270_/A _3229_/A _3744_/Q VGND VGND VPWR VPWR _3220_/X sky130_fd_sc_hd__a22o_1
X_3151_ input58/X _3761_/Q _3165_/S VGND VGND VPWR VPWR _3761_/D sky130_fd_sc_hd__mux2_1
XFILLER_11_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2102_ _2102_/A _2102_/B _2102_/C VGND VGND VPWR VPWR _2107_/B sky130_fd_sc_hd__nor3_1
X_3082_ _3082_/A _3082_/B VGND VGND VPWR VPWR _3083_/B sky130_fd_sc_hd__nor2_1
XFILLER_54_218 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2033_ _3726_/Q VGND VGND VPWR VPWR _2034_/B sky130_fd_sc_hd__inv_2
XFILLER_47_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_126 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2935_ _3719_/Q _2935_/B VGND VGND VPWR VPWR _2940_/A sky130_fd_sc_hd__nor2_1
XFILLER_30_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2866_ _3011_/B _2864_/A _2862_/X _2863_/Y _2865_/X VGND VGND VPWR VPWR _2867_/S
+ sky130_fd_sc_hd__o2111a_1
X_1817_ _1830_/A VGND VGND VPWR VPWR _3368_/B sky130_fd_sc_hd__inv_2
XFILLER_7_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2797_ _2797_/A _2797_/B VGND VGND VPWR VPWR _2797_/X sky130_fd_sc_hd__or2_1
X_3418_ _3670_/Q _3606_/B _3390_/Y VGND VGND VPWR VPWR _3418_/X sky130_fd_sc_hd__o21a_1
X_3349_ _3848_/Q _2231_/X _3827_/D VGND VGND VPWR VPWR _3848_/D sky130_fd_sc_hd__mux2_1
XTAP_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_218 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2720_ _3690_/Q _2720_/B _2746_/B VGND VGND VPWR VPWR _2720_/X sky130_fd_sc_hd__or3_1
XFILLER_12_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2651_ _2371_/A _2648_/X _2650_/X VGND VGND VPWR VPWR _2651_/X sky130_fd_sc_hd__a21o_1
Xclkbuf_leaf_17_i_clk clkbuf_2_3__f_i_clk/X VGND VGND VPWR VPWR _3861_/CLK sky130_fd_sc_hd__clkbuf_16
X_2582_ _3728_/Q _2856_/B _3736_/Q _2600_/A _2581_/Y VGND VGND VPWR VPWR _2582_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_59_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3203_ _3203_/A _3203_/B _3203_/C VGND VGND VPWR VPWR _3207_/A sky130_fd_sc_hd__nor3_1
X_3134_ _3141_/S _1894_/B _2941_/A VGND VGND VPWR VPWR _3134_/X sky130_fd_sc_hd__a21o_1
XFILLER_27_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3065_ _2949_/A _2134_/B _2443_/X _3064_/X _2818_/A VGND VGND VPWR VPWR _3081_/A
+ sky130_fd_sc_hd__o2111a_1
X_2016_ input5/X _3724_/Q VGND VGND VPWR VPWR _2019_/B sky130_fd_sc_hd__xor2_1
XFILLER_23_413 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2918_ _3713_/Q _2914_/B _3022_/B _2917_/X VGND VGND VPWR VPWR _3713_/D sky130_fd_sc_hd__o211a_1
X_3898_ _3903_/CLK _3898_/D VGND VGND VPWR VPWR _3898_/Q sky130_fd_sc_hd__dfxtp_1
X_2849_ _2848_/X _2453_/B _2330_/B VGND VGND VPWR VPWR _2849_/Y sky130_fd_sc_hd__a21boi_1
XFILLER_58_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_240 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3821_ _3903_/CLK _3821_/D VGND VGND VPWR VPWR _3821_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_32_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3752_ _3759_/CLK _3752_/D VGND VGND VPWR VPWR _3752_/Q sky130_fd_sc_hd__dfxtp_4
X_3683_ _3687_/CLK _3683_/D VGND VGND VPWR VPWR _3683_/Q sky130_fd_sc_hd__dfxtp_1
X_2703_ _3775_/Q _2782_/A _2702_/X VGND VGND VPWR VPWR _2703_/X sky130_fd_sc_hd__a21o_1
X_2634_ _3770_/Q _3058_/B _3032_/C VGND VGND VPWR VPWR _2634_/Y sky130_fd_sc_hd__o21ai_1
X_2565_ _3468_/B _2796_/B _2564_/Y _2042_/B _3011_/A VGND VGND VPWR VPWR _2565_/X
+ sky130_fd_sc_hd__o32a_1
X_2496_ _2746_/B VGND VGND VPWR VPWR _2839_/A sky130_fd_sc_hd__clkinv_8
X_3117_ _3116_/X _3130_/B _3184_/A VGND VGND VPWR VPWR _3117_/Y sky130_fd_sc_hd__a21oi_1
XFILLER_67_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3048_ _3048_/A _3048_/B VGND VGND VPWR VPWR _3049_/A sky130_fd_sc_hd__nand2_1
XFILLER_63_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_24 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_427 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2350_ _2350_/A _2929_/A VGND VGND VPWR VPWR _2930_/A sky130_fd_sc_hd__nand2_1
X_2281_ _3184_/A _2822_/A VGND VGND VPWR VPWR _3016_/B sky130_fd_sc_hd__nor2_2
XFILLER_37_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3804_ _3838_/CLK _3804_/D VGND VGND VPWR VPWR _3804_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_20_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1996_ _2094_/A _3742_/Q _1996_/C VGND VGND VPWR VPWR _1997_/C sky130_fd_sc_hd__nand3b_1
X_3735_ _3849_/CLK _3735_/D VGND VGND VPWR VPWR _3735_/Q sky130_fd_sc_hd__dfxtp_1
X_3666_ _3897_/CLK _3666_/D VGND VGND VPWR VPWR _3666_/Q sky130_fd_sc_hd__dfxtp_1
X_3597_ _3601_/A _3596_/Y _3580_/Y VGND VGND VPWR VPWR _3597_/Y sky130_fd_sc_hd__a21oi_1
X_2617_ _3492_/B _2796_/B VGND VGND VPWR VPWR _2617_/Y sky130_fd_sc_hd__nor2_1
X_2548_ _2547_/X _3676_/Q _2793_/A VGND VGND VPWR VPWR _3676_/D sky130_fd_sc_hd__mux2_1
X_2479_ _2842_/C _2600_/A VGND VGND VPWR VPWR _2480_/A sky130_fd_sc_hd__nor2_1
XFILLER_18_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_66 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1850_ _3747_/Q VGND VGND VPWR VPWR _3036_/A sky130_fd_sc_hd__inv_2
XFILLER_42_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3520_ _3522_/B _3553_/A _3411_/A VGND VGND VPWR VPWR _3520_/Y sky130_fd_sc_hd__a21oi_1
X_3451_ _3556_/A _3672_/Q _3450_/X _3406_/Y VGND VGND VPWR VPWR _3451_/X sky130_fd_sc_hd__a211o_1
X_3382_ _3382_/A _3382_/B VGND VGND VPWR VPWR _3385_/S sky130_fd_sc_hd__nand2_1
X_2402_ _3665_/Q VGND VGND VPWR VPWR _2403_/A sky130_fd_sc_hd__inv_2
X_2333_ _3829_/Q VGND VGND VPWR VPWR _3067_/B sky130_fd_sc_hd__clkinv_2
X_2264_ _2782_/A _2842_/C VGND VGND VPWR VPWR _2371_/A sky130_fd_sc_hd__nor2_2
X_2195_ _3327_/B VGND VGND VPWR VPWR _2244_/S sky130_fd_sc_hd__clkbuf_16
XFILLER_37_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_157 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1979_ _1968_/X _2006_/B _1977_/Y _2102_/C VGND VGND VPWR VPWR _1983_/B sky130_fd_sc_hd__o211ai_1
X_3718_ _3759_/CLK _3718_/D VGND VGND VPWR VPWR _3718_/Q sky130_fd_sc_hd__dfxtp_1
X_3649_ _3852_/CLK _3649_/D VGND VGND VPWR VPWR _3649_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_20_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_9 _2165_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_143 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_452 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2951_ _3661_/Q _3827_/Q _3077_/C _3131_/B VGND VGND VPWR VPWR _2952_/A sky130_fd_sc_hd__a31o_1
XFILLER_62_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1902_ _3176_/B VGND VGND VPWR VPWR _3094_/A sky130_fd_sc_hd__clkinv_2
XFILLER_30_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2882_ _3704_/Q _2885_/A VGND VGND VPWR VPWR _2886_/A sky130_fd_sc_hd__or2_1
X_1833_ _3606_/B VGND VGND VPWR VPWR _3553_/A sky130_fd_sc_hd__clkinv_8
X_3503_ _3499_/X _3501_/X _3502_/Y _3884_/Q _3577_/A VGND VGND VPWR VPWR _3884_/D
+ sky130_fd_sc_hd__a32o_1
X_3434_ _3872_/Q _3869_/Q _3552_/S VGND VGND VPWR VPWR _3435_/B sky130_fd_sc_hd__mux2_1
XTAP_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3365_ _3699_/Q _2863_/A _3861_/Q _3053_/A _3364_/X VGND VGND VPWR VPWR _3365_/X
+ sky130_fd_sc_hd__a221o_1
XTAP_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3296_ _3559_/B _3559_/A VGND VGND VPWR VPWR _3296_/Y sky130_fd_sc_hd__nand2_1
X_2316_ _3784_/Q VGND VGND VPWR VPWR _3190_/A sky130_fd_sc_hd__inv_2
X_2247_ _3654_/Q _3651_/Q _3826_/Q VGND VGND VPWR VPWR _2247_/X sky130_fd_sc_hd__mux2_1
X_2178_ _2362_/B _3121_/B _2369_/B VGND VGND VPWR VPWR _2439_/A sky130_fd_sc_hd__o21a_1
XFILLER_53_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput79 _3790_/Q VGND VGND VPWR VPWR o_wb_data[17] sky130_fd_sc_hd__clkbuf_1
Xoutput68 _1842_/Y VGND VGND VPWR VPWR o_qspi_mod[1] sky130_fd_sc_hd__clkbuf_1
XFILLER_48_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3150_ input57/X _3760_/Q _3165_/S VGND VGND VPWR VPWR _3760_/D sky130_fd_sc_hd__mux2_1
X_3081_ _3081_/A _3081_/B _3081_/C VGND VGND VPWR VPWR _3082_/B sky130_fd_sc_hd__nand3_1
XFILLER_39_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2101_ _2101_/A _2101_/B _2101_/C VGND VGND VPWR VPWR _2107_/A sky130_fd_sc_hd__and3_1
X_2032_ _2032_/A _2032_/B VGND VGND VPWR VPWR _2054_/A sky130_fd_sc_hd__nand2_1
XFILLER_47_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2934_ _3718_/Q _2930_/X _2933_/Y VGND VGND VPWR VPWR _3718_/D sky130_fd_sc_hd__a21o_1
X_2865_ _2864_/Y _3044_/B _3020_/A VGND VGND VPWR VPWR _2865_/X sky130_fd_sc_hd__a21o_1
X_1816_ _3865_/Q _3291_/B VGND VGND VPWR VPWR _1830_/A sky130_fd_sc_hd__nor2_1
X_2796_ _3571_/B _2796_/B VGND VGND VPWR VPWR _2797_/B sky130_fd_sc_hd__nor2_1
X_3417_ _3568_/A _3417_/B VGND VGND VPWR VPWR _3417_/X sky130_fd_sc_hd__or2_1
X_3348_ _3847_/Q _2229_/X _3827_/D VGND VGND VPWR VPWR _3847_/D sky130_fd_sc_hd__mux2_1
XTAP_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3279_ _3314_/A _3279_/B VGND VGND VPWR VPWR _3379_/B sky130_fd_sc_hd__nand2_2
XFILLER_26_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_263 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_20 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_i_clk i_clk VGND VGND VPWR VPWR clkbuf_0_i_clk/X sky130_fd_sc_hd__clkbuf_16
XFILLER_67_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_447 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2650_ _2681_/A _2782_/A _2842_/C _2885_/A _2856_/A VGND VGND VPWR VPWR _2650_/X
+ sky130_fd_sc_hd__a221o_1
X_2581_ _1976_/B _2842_/C _2580_/X VGND VGND VPWR VPWR _2581_/Y sky130_fd_sc_hd__a21oi_1
XFILLER_4_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3202_ _3202_/A _3202_/B _3202_/C _3202_/D VGND VGND VPWR VPWR _3203_/C sky130_fd_sc_hd__or4_1
X_3133_ _3011_/B _2160_/C _3132_/Y VGND VGND VPWR VPWR _3133_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_82_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3064_ _1947_/A _2949_/A _2443_/A _2332_/A VGND VGND VPWR VPWR _3064_/X sky130_fd_sc_hd__o31a_1
X_2015_ _2015_/A _2540_/B VGND VGND VPWR VPWR _2019_/A sky130_fd_sc_hd__nand2_1
XFILLER_35_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2917_ _3837_/Q _3623_/A _2916_/Y _2901_/Y VGND VGND VPWR VPWR _2917_/X sky130_fd_sc_hd__a211o_1
X_3897_ _3897_/CLK _3897_/D VGND VGND VPWR VPWR _3897_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_12_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2848_ _3023_/B _3121_/B _3094_/A _3177_/B _2847_/X VGND VGND VPWR VPWR _2848_/X
+ sky130_fd_sc_hd__a32o_1
X_2779_ _3199_/C _2779_/B VGND VGND VPWR VPWR _2779_/Y sky130_fd_sc_hd__nand2_1
XTAP_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_156 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3820_ _3903_/CLK _3820_/D VGND VGND VPWR VPWR _3820_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_32_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3751_ _3767_/CLK _3751_/D VGND VGND VPWR VPWR _3751_/Q sky130_fd_sc_hd__dfxtp_1
X_2702_ _2916_/A _2895_/B _3713_/Q _2842_/A VGND VGND VPWR VPWR _2702_/X sky130_fd_sc_hd__a2bb2o_1
XFILLER_71_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3682_ _3687_/CLK _3682_/D VGND VGND VPWR VPWR _3682_/Q sky130_fd_sc_hd__dfxtp_1
X_2633_ _2713_/A _2631_/Y _2632_/X VGND VGND VPWR VPWR _2633_/X sky130_fd_sc_hd__a21bo_1
X_2564_ _2608_/A VGND VGND VPWR VPWR _2564_/Y sky130_fd_sc_hd__clkinv_2
X_2495_ _2494_/X _3669_/Q _2793_/A VGND VGND VPWR VPWR _3669_/D sky130_fd_sc_hd__mux2_1
XFILLER_59_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_100 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3116_ _3113_/X _3114_/Y _3115_/Y VGND VGND VPWR VPWR _3116_/X sky130_fd_sc_hd__a21o_1
XFILLER_55_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3047_ _3105_/B VGND VGND VPWR VPWR _3048_/B sky130_fd_sc_hd__inv_2
XFILLER_23_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_406 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_16_i_clk clkbuf_2_3__f_i_clk/X VGND VGND VPWR VPWR _3852_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_61_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2280_ _2423_/B VGND VGND VPWR VPWR _2822_/A sky130_fd_sc_hd__inv_2
XFILLER_36_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3803_ _3838_/CLK _3803_/D VGND VGND VPWR VPWR _3803_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_20_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1995_ _2069_/A _2012_/B VGND VGND VPWR VPWR _2094_/A sky130_fd_sc_hd__nand2_1
XFILLER_20_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3734_ _3736_/CLK _3734_/D VGND VGND VPWR VPWR _3734_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_9_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3665_ _3897_/CLK _3665_/D VGND VGND VPWR VPWR _3665_/Q sky130_fd_sc_hd__dfxtp_1
X_2616_ _3682_/Q VGND VGND VPWR VPWR _3492_/B sky130_fd_sc_hd__inv_2
X_3596_ _3596_/A _3606_/B VGND VGND VPWR VPWR _3596_/Y sky130_fd_sc_hd__nor2_1
X_2547_ _2547_/A _2547_/B _2547_/C _2547_/D VGND VGND VPWR VPWR _2547_/X sky130_fd_sc_hd__or4_1
X_2478_ _2478_/A _3032_/C VGND VGND VPWR VPWR _2600_/A sky130_fd_sc_hd__nor2_2
XFILLER_68_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_350 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3450_ _3555_/A _3675_/Q VGND VGND VPWR VPWR _3450_/X sky130_fd_sc_hd__and2_1
X_3381_ _3381_/A _3381_/B _3389_/A VGND VGND VPWR VPWR _3382_/A sky130_fd_sc_hd__and3_1
X_2401_ _3664_/Q _2395_/X _3022_/B _2400_/Y VGND VGND VPWR VPWR _3664_/D sky130_fd_sc_hd__o211a_1
XFILLER_69_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2332_ _2332_/A _2832_/B VGND VGND VPWR VPWR _2373_/B sky130_fd_sc_hd__and2_1
X_2263_ _2842_/A _2833_/A VGND VGND VPWR VPWR _3177_/B sky130_fd_sc_hd__nor2_2
X_2194_ _2194_/A _3864_/Q VGND VGND VPWR VPWR _3327_/B sky130_fd_sc_hd__nand2_8
XFILLER_80_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3717_ _3759_/CLK _3717_/D VGND VGND VPWR VPWR _3717_/Q sky130_fd_sc_hd__dfxtp_1
X_1978_ input8/X _1976_/B _1968_/X VGND VGND VPWR VPWR _2102_/C sky130_fd_sc_hd__a21o_1
X_3648_ _3849_/CLK _3648_/D VGND VGND VPWR VPWR _3648_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_20_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3579_ _3579_/A _3579_/B VGND VGND VPWR VPWR _3580_/A sky130_fd_sc_hd__nor2_2
XFILLER_0_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_78 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_464 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2950_ _3016_/B VGND VGND VPWR VPWR _3203_/A sky130_fd_sc_hd__inv_2
X_1901_ _3661_/Q _3829_/Q VGND VGND VPWR VPWR _3176_/B sky130_fd_sc_hd__nor2_4
XFILLER_30_320 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2881_ _2881_/A _2881_/B _2881_/C _2881_/D VGND VGND VPWR VPWR _2881_/X sky130_fd_sc_hd__and4_1
X_1832_ _2194_/A _3275_/B VGND VGND VPWR VPWR _3606_/B sky130_fd_sc_hd__nand2_8
X_3502_ _3504_/B _3553_/A _3411_/A VGND VGND VPWR VPWR _3502_/Y sky130_fd_sc_hd__a21oi_1
X_3433_ _3556_/A _3669_/Q _3432_/X _3406_/Y VGND VGND VPWR VPWR _3433_/X sky130_fd_sc_hd__a211o_1
XTAP_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3364_ _3196_/A _3830_/Q _3196_/B _2954_/A _3861_/Q VGND VGND VPWR VPWR _3364_/X
+ sky130_fd_sc_hd__a32o_1
XTAP_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3295_ _3693_/Q VGND VGND VPWR VPWR _3559_/B sky130_fd_sc_hd__inv_2
X_2315_ _2313_/Y _1915_/A _2164_/X _2408_/B VGND VGND VPWR VPWR _2315_/X sky130_fd_sc_hd__a211o_1
XFILLER_57_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2246_ _2245_/X _3654_/Q _3327_/B VGND VGND VPWR VPWR _3654_/D sky130_fd_sc_hd__mux2_1
XFILLER_72_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2177_ _3699_/Q VGND VGND VPWR VPWR _3121_/B sky130_fd_sc_hd__inv_2
XFILLER_25_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput69 _1839_/X VGND VGND VPWR VPWR o_qspi_sck sky130_fd_sc_hd__clkbuf_1
XFILLER_0_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3080_ _3661_/Q _2368_/C _3074_/X _3075_/Y _3079_/Y VGND VGND VPWR VPWR _3081_/C
+ sky130_fd_sc_hd__a2111oi_1
XFILLER_39_228 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2100_ _2100_/A _3784_/Q _2762_/B VGND VGND VPWR VPWR _2101_/A sky130_fd_sc_hd__and3_1
X_2031_ _2006_/A _2006_/B _2101_/B VGND VGND VPWR VPWR _2032_/B sky130_fd_sc_hd__o21bai_1
XPHY_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2933_ _2935_/B _3022_/B VGND VGND VPWR VPWR _2933_/Y sky130_fd_sc_hd__nand2_1
XFILLER_50_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2864_ _2864_/A _3119_/A VGND VGND VPWR VPWR _2864_/Y sky130_fd_sc_hd__nand2_1
X_2795_ _3695_/Q VGND VGND VPWR VPWR _3571_/B sky130_fd_sc_hd__inv_2
X_1815_ _3864_/Q _3863_/Q VGND VGND VPWR VPWR _3291_/B sky130_fd_sc_hd__nand2_1
X_3416_ _3869_/Q _3866_/Q _3552_/S VGND VGND VPWR VPWR _3417_/B sky130_fd_sc_hd__mux2_1
X_3347_ _3846_/Q _2227_/X _3827_/D VGND VGND VPWR VPWR _3846_/D sky130_fd_sc_hd__mux2_1
XTAP_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3278_ _3291_/A _3292_/B VGND VGND VPWR VPWR _3389_/B sky130_fd_sc_hd__nor2_1
XFILLER_45_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2229_ _3645_/Q _3642_/Q _3362_/S VGND VGND VPWR VPWR _2229_/X sky130_fd_sc_hd__mux2_1
XFILLER_53_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_18 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_32 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_459 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2580_ _2693_/A _3057_/B _2601_/A _3058_/B _2948_/A VGND VGND VPWR VPWR _2580_/X
+ sky130_fd_sc_hd__o221a_1
XFILLER_79_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3201_ _2430_/B _3048_/B _2429_/B _2742_/B VGND VGND VPWR VPWR _3202_/D sky130_fd_sc_hd__a2bb2o_1
X_3132_ _3132_/A _3132_/B _3132_/C VGND VGND VPWR VPWR _3132_/Y sky130_fd_sc_hd__nand3_1
X_3063_ _3056_/Y _3062_/X _2411_/Y VGND VGND VPWR VPWR _3082_/A sky130_fd_sc_hd__o21a_1
XFILLER_35_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2014_ _3119_/A _2749_/A VGND VGND VPWR VPWR _2015_/A sky130_fd_sc_hd__nand2_1
XFILLER_35_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3896_ _3896_/CLK _3896_/D VGND VGND VPWR VPWR _3896_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_10_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2916_ _2916_/A _3623_/A VGND VGND VPWR VPWR _2916_/Y sky130_fd_sc_hd__nor2_1
X_2847_ _2329_/B _3121_/B _2330_/A VGND VGND VPWR VPWR _2847_/X sky130_fd_sc_hd__a21o_1
X_2778_ _2797_/A _2775_/Y _2777_/Y VGND VGND VPWR VPWR _2778_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_77_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_212 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_164 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3750_ _3766_/CLK _3750_/D VGND VGND VPWR VPWR _3750_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_9_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2701_ _2701_/A _2721_/B VGND VGND VPWR VPWR _2701_/Y sky130_fd_sc_hd__nor2_1
XFILLER_9_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3681_ _3687_/CLK _3681_/D VGND VGND VPWR VPWR _3681_/Q sky130_fd_sc_hd__dfxtp_1
X_2632_ _3754_/Q _2895_/B _3710_/Q _3057_/B VGND VGND VPWR VPWR _2632_/X sky130_fd_sc_hd__o22a_1
X_2563_ _2561_/Y _2562_/X _2480_/Y _3735_/Q VGND VGND VPWR VPWR _2563_/Y sky130_fd_sc_hd__a22oi_1
X_2494_ _3122_/B _2492_/X _2608_/A _2491_/Y _2493_/X VGND VGND VPWR VPWR _2494_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_4_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3115_ _3176_/B _3009_/S _2293_/A VGND VGND VPWR VPWR _3115_/Y sky130_fd_sc_hd__o21ai_1
X_3046_ _3046_/A _3046_/B _3046_/C VGND VGND VPWR VPWR _3048_/A sky130_fd_sc_hd__nand3_1
XFILLER_55_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_145 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3879_ _3882_/CLK _3879_/D VGND VGND VPWR VPWR _3879_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_78_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_359 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3802_ _3838_/CLK _3802_/D VGND VGND VPWR VPWR _3802_/Q sky130_fd_sc_hd__dfxtp_1
X_1994_ _2069_/A _3742_/Q _2012_/B _2103_/B VGND VGND VPWR VPWR _1997_/B sky130_fd_sc_hd__a31o_1
X_3733_ _3733_/CLK _3733_/D VGND VGND VPWR VPWR _3733_/Q sky130_fd_sc_hd__dfxtp_2
XFILLER_9_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3664_ _3901_/CLK _3664_/D VGND VGND VPWR VPWR _3664_/Q sky130_fd_sc_hd__dfxtp_1
X_2615_ _3486_/B _2559_/Y _2614_/X VGND VGND VPWR VPWR _3681_/D sky130_fd_sc_hd__o21ai_1
X_3595_ _3595_/A _3595_/B VGND VGND VPWR VPWR _3595_/X sky130_fd_sc_hd__and2_1
X_2546_ _2544_/X _2545_/X _2480_/Y _3733_/Q VGND VGND VPWR VPWR _2547_/D sky130_fd_sc_hd__a22o_1
X_2477_ _2477_/A _2711_/A VGND VGND VPWR VPWR _2478_/A sky130_fd_sc_hd__nand2_1
XFILLER_68_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3029_ _3029_/A _3029_/B VGND VGND VPWR VPWR _3031_/A sky130_fd_sc_hd__nand2_1
XFILLER_43_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_469 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_91 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2400_ _2398_/X _2399_/Y _2395_/X VGND VGND VPWR VPWR _2400_/Y sky130_fd_sc_hd__o21ai_1
X_3380_ _3380_/A VGND VGND VPWR VPWR _3389_/A sky130_fd_sc_hd__inv_2
XFILLER_69_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2331_ _2854_/D VGND VGND VPWR VPWR _2332_/A sky130_fd_sc_hd__inv_2
X_2262_ _2752_/B _2895_/B VGND VGND VPWR VPWR _2833_/A sky130_fd_sc_hd__nand2_1
XFILLER_27_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2193_ input2/X input1/X _3362_/S VGND VGND VPWR VPWR _2193_/X sky130_fd_sc_hd__mux2_1
XFILLER_80_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_189 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3716_ _3759_/CLK _3716_/D VGND VGND VPWR VPWR _3716_/Q sky130_fd_sc_hd__dfxtp_1
X_1977_ _2105_/A VGND VGND VPWR VPWR _1977_/Y sky130_fd_sc_hd__inv_2
Xclkbuf_leaf_15_i_clk clkbuf_leaf_9_i_clk/A VGND VGND VPWR VPWR _3848_/CLK sky130_fd_sc_hd__clkbuf_16
X_3647_ _3848_/CLK _3647_/D VGND VGND VPWR VPWR _3647_/Q sky130_fd_sc_hd__dfxtp_1
X_3578_ _2403_/A _3606_/B _3577_/Y VGND VGND VPWR VPWR _3897_/D sky130_fd_sc_hd__o21ai_1
XFILLER_0_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_428 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2529_ _3122_/B _2524_/X _2608_/A _2523_/Y _2528_/X VGND VGND VPWR VPWR _2529_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_29_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_318 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2880_ _2880_/A _3701_/Q VGND VGND VPWR VPWR _2881_/D sky130_fd_sc_hd__nand2_1
X_1900_ _1900_/A _2187_/B VGND VGND VPWR VPWR _3011_/B sky130_fd_sc_hd__nand2_8
X_1831_ _3865_/Q _3379_/A VGND VGND VPWR VPWR _2194_/A sky130_fd_sc_hd__nor2_4
XFILLER_30_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3501_ _3568_/A _3501_/B VGND VGND VPWR VPWR _3501_/X sky130_fd_sc_hd__or2_1
X_3432_ _3555_/A _3672_/Q VGND VGND VPWR VPWR _3432_/X sky130_fd_sc_hd__and2_1
XTAP_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3363_ _3861_/Q _3362_/X _3363_/S VGND VGND VPWR VPWR _3861_/D sky130_fd_sc_hd__mux2_1
XTAP_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3294_ _3571_/A VGND VGND VPWR VPWR _3559_/A sky130_fd_sc_hd__buf_6
X_2314_ _3049_/B _3190_/B VGND VGND VPWR VPWR _2408_/B sky130_fd_sc_hd__nand2_1
X_2245_ _3653_/Q _3650_/Q _3826_/Q VGND VGND VPWR VPWR _2245_/X sky130_fd_sc_hd__mux2_1
X_2176_ _2176_/A _2436_/B VGND VGND VPWR VPWR _2176_/Y sky130_fd_sc_hd__nand2_1
XFILLER_53_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2030_ _2030_/A _2030_/B VGND VGND VPWR VPWR _2032_/A sky130_fd_sc_hd__nor2_1
XFILLER_62_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2932_ _2932_/A _3022_/A VGND VGND VPWR VPWR _2935_/B sky130_fd_sc_hd__or2_1
XFILLER_62_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2863_ _2863_/A _2863_/B VGND VGND VPWR VPWR _2863_/Y sky130_fd_sc_hd__nor2_1
X_1814_ _3829_/Q _2370_/B VGND VGND VPWR VPWR _3367_/B sky130_fd_sc_hd__nor2_4
X_2794_ _2780_/Y _2793_/A _2792_/Y _2793_/Y VGND VGND VPWR VPWR _3694_/D sky130_fd_sc_hd__o31a_1
XFILLER_7_61 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3415_ _3556_/A _3666_/Q _3414_/Y _3406_/Y VGND VGND VPWR VPWR _3415_/X sky130_fd_sc_hd__a211o_1
X_3346_ _3845_/Q _2225_/X _3827_/D VGND VGND VPWR VPWR _3845_/D sky130_fd_sc_hd__mux2_1
XTAP_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3277_ _3828_/Q _3314_/A VGND VGND VPWR VPWR _3292_/B sky130_fd_sc_hd__nor2_1
XTAP_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2228_ _2227_/X _3645_/Q _2244_/S VGND VGND VPWR VPWR _3645_/D sky130_fd_sc_hd__mux2_1
XFILLER_38_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2159_ _2810_/B _2159_/B VGND VGND VPWR VPWR _2160_/C sky130_fd_sc_hd__nor2_1
XFILLER_26_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_44 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3200_ _2438_/Y _2437_/A _2953_/A _2856_/B VGND VGND VPWR VPWR _3202_/C sky130_fd_sc_hd__a211o_1
X_3131_ _3131_/A _3131_/B _3131_/C VGND VGND VPWR VPWR _3132_/C sky130_fd_sc_hd__and3_1
XFILLER_67_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3062_ _2897_/A _3057_/Y _3058_/Y _3061_/Y _2415_/Y VGND VGND VPWR VPWR _3062_/X
+ sky130_fd_sc_hd__o41a_1
X_2013_ _2013_/A _2013_/B VGND VGND VPWR VPWR _2065_/A sky130_fd_sc_hd__nand2_1
XFILLER_23_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3895_ _3896_/CLK _3895_/D VGND VGND VPWR VPWR _3895_/Q sky130_fd_sc_hd__dfxtp_1
X_2915_ _2913_/X _2901_/Y _3022_/B _2914_/X VGND VGND VPWR VPWR _3712_/D sky130_fd_sc_hd__o211a_1
X_2846_ _2838_/Y _2845_/A _2845_/Y VGND VGND VPWR VPWR _3698_/D sky130_fd_sc_hd__o21ai_1
X_2777_ _2777_/A _2798_/A VGND VGND VPWR VPWR _2777_/Y sky130_fd_sc_hd__nor2_1
XTAP_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3329_ _3329_/A _3585_/A VGND VGND VPWR VPWR _3384_/A sky130_fd_sc_hd__nand2_1
XTAP_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_176 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2700_ _3528_/B _2796_/B VGND VGND VPWR VPWR _2700_/Y sky130_fd_sc_hd__nor2_1
X_3680_ _3687_/CLK _3680_/D VGND VGND VPWR VPWR _3680_/Q sky130_fd_sc_hd__dfxtp_1
X_2631_ _2876_/S _3768_/Q VGND VGND VPWR VPWR _2631_/Y sky130_fd_sc_hd__nand2_1
X_2562_ _3765_/Q _3058_/B VGND VGND VPWR VPWR _2562_/X sky130_fd_sc_hd__or2_1
X_2493_ _3756_/Q _2782_/A _2480_/Y _3726_/Q VGND VGND VPWR VPWR _2493_/X sky130_fd_sc_hd__a22o_1
X_3114_ _2476_/A _2754_/A _2856_/A VGND VGND VPWR VPWR _3114_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_67_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3045_ _2312_/Y _2788_/Y _3044_/Y _2721_/B _3011_/A VGND VGND VPWR VPWR _3046_/C
+ sky130_fd_sc_hd__o311a_1
XFILLER_55_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_246 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3878_ _3886_/CLK _3878_/D VGND VGND VPWR VPWR _3878_/Q sky130_fd_sc_hd__dfxtp_1
X_2829_ _2829_/A _3032_/A VGND VGND VPWR VPWR _3088_/B sky130_fd_sc_hd__nand2_1
XFILLER_2_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_202 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3801_ _3838_/CLK _3801_/D VGND VGND VPWR VPWR _3801_/Q sky130_fd_sc_hd__dfxtp_1
X_1993_ _1996_/C _1993_/B VGND VGND VPWR VPWR _2103_/B sky130_fd_sc_hd__and2_1
XFILLER_9_250 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3732_ _3733_/CLK _3732_/D VGND VGND VPWR VPWR _3732_/Q sky130_fd_sc_hd__dfxtp_2
X_3663_ _3901_/CLK _3663_/D VGND VGND VPWR VPWR _3663_/Q sky130_fd_sc_hd__dfxtp_1
X_2614_ _2607_/X _2609_/Y _2610_/X _2613_/X _2793_/A VGND VGND VPWR VPWR _2614_/X
+ sky130_fd_sc_hd__a41o_1
X_3594_ _3594_/A _3900_/Q VGND VGND VPWR VPWR _3595_/B sky130_fd_sc_hd__nand2_1
X_2545_ _3763_/Q _3058_/B VGND VGND VPWR VPWR _2545_/X sky130_fd_sc_hd__or2_1
X_2476_ _2476_/A VGND VGND VPWR VPWR _2711_/A sky130_fd_sc_hd__inv_2
XFILLER_68_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3028_ _3028_/A _3028_/B VGND VGND VPWR VPWR _3029_/A sky130_fd_sc_hd__nand2_1
XFILLER_51_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2330_ _2330_/A _2330_/B VGND VGND VPWR VPWR _2854_/D sky130_fd_sc_hd__nor2_1
X_2261_ _3057_/B VGND VGND VPWR VPWR _2842_/A sky130_fd_sc_hd__clkinv_2
X_2192_ _3826_/Q VGND VGND VPWR VPWR _3362_/S sky130_fd_sc_hd__buf_12
XFILLER_1_30 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1976_ input8/X _1976_/B VGND VGND VPWR VPWR _2105_/A sky130_fd_sc_hd__nor2_1
X_3715_ _3759_/CLK _3715_/D VGND VGND VPWR VPWR _3715_/Q sky130_fd_sc_hd__dfxtp_1
X_3646_ _3848_/CLK _3646_/D VGND VGND VPWR VPWR _3646_/Q sky130_fd_sc_hd__dfxtp_1
X_3577_ _3577_/A _3897_/Q VGND VGND VPWR VPWR _3577_/Y sky130_fd_sc_hd__nand2_1
X_2528_ _2526_/Y _2527_/X _2480_/Y _3731_/Q VGND VGND VPWR VPWR _2528_/X sky130_fd_sc_hd__a22o_1
X_2459_ _2459_/A VGND VGND VPWR VPWR _2460_/B sky130_fd_sc_hd__inv_2
XFILLER_28_146 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_455 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1830_ _1830_/A _3661_/Q _3379_/A VGND VGND VPWR VPWR _1830_/X sky130_fd_sc_hd__and3_1
XFILLER_30_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3500_ _3883_/Q _3880_/Q _3552_/S VGND VGND VPWR VPWR _3501_/B sky130_fd_sc_hd__mux2_1
XFILLER_30_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3431_ _3427_/X _3429_/X _3430_/X _3872_/Q _3577_/A VGND VGND VPWR VPWR _3872_/D
+ sky130_fd_sc_hd__a32o_1
XTAP_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3362_ _3659_/Q _3656_/Q _3362_/S VGND VGND VPWR VPWR _3362_/X sky130_fd_sc_hd__mux2_1
XTAP_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2313_ _2159_/B _3099_/B _2312_/Y VGND VGND VPWR VPWR _2313_/Y sky130_fd_sc_hd__a21oi_1
XTAP_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3293_ _3293_/A VGND VGND VPWR VPWR _3306_/B sky130_fd_sc_hd__clkbuf_2
XTAP_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2244_ _2243_/X _3653_/Q _2244_/S VGND VGND VPWR VPWR _3653_/D sky130_fd_sc_hd__mux2_1
X_2175_ _2175_/A VGND VGND VPWR VPWR _2436_/B sky130_fd_sc_hd__inv_2
XFILLER_21_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1959_ _3726_/Q _3727_/Q VGND VGND VPWR VPWR _2044_/A sky130_fd_sc_hd__nand2_1
X_3629_ _3830_/CLK _3629_/D VGND VGND VPWR VPWR _3629_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_29_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_255 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_171 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_458 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_14_i_clk clkbuf_2_3__f_i_clk/X VGND VGND VPWR VPWR _3849_/CLK sky130_fd_sc_hd__clkbuf_16
X_2931_ _2941_/A _2931_/B _2930_/X VGND VGND VPWR VPWR _3717_/D sky130_fd_sc_hd__or3b_1
XFILLER_50_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2862_ _2777_/A _3199_/B _2436_/B _3049_/B VGND VGND VPWR VPWR _2862_/X sky130_fd_sc_hd__a31o_1
Xclkbuf_leaf_29_i_clk clkbuf_2_2__f_i_clk/X VGND VGND VPWR VPWR _3874_/CLK sky130_fd_sc_hd__clkbuf_16
X_1813_ _3661_/Q VGND VGND VPWR VPWR _2370_/B sky130_fd_sc_hd__clkinv_2
X_2793_ _2793_/A _3565_/B VGND VGND VPWR VPWR _2793_/Y sky130_fd_sc_hd__nand2_1
XFILLER_7_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3414_ _3559_/A _3414_/B VGND VGND VPWR VPWR _3414_/Y sky130_fd_sc_hd__nor2_1
X_3345_ _3844_/Q _2223_/X _3827_/D VGND VGND VPWR VPWR _3844_/D sky130_fd_sc_hd__mux2_1
XTAP_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3276_ _3864_/Q _3327_/A VGND VGND VPWR VPWR _3314_/A sky130_fd_sc_hd__nor2_1
XTAP_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2227_ _3644_/Q _3641_/Q _3362_/S VGND VGND VPWR VPWR _2227_/X sky130_fd_sc_hd__mux2_1
XTAP_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2158_ _2449_/A _3119_/A _2157_/Y VGND VGND VPWR VPWR _2159_/B sky130_fd_sc_hd__a21oi_1
XFILLER_53_200 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2089_ _2095_/A _2104_/B VGND VGND VPWR VPWR _2092_/A sky130_fd_sc_hd__nand2_1
XFILLER_34_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_336 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3130_ _3130_/A _3130_/B VGND VGND VPWR VPWR _3132_/A sky130_fd_sc_hd__nand2_1
XFILLER_79_185 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3061_ _3059_/Y _3060_/Y _3113_/C VGND VGND VPWR VPWR _3061_/Y sky130_fd_sc_hd__a21oi_1
XFILLER_75_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_200 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2012_ _2069_/A _2012_/B _2100_/A VGND VGND VPWR VPWR _2013_/B sky130_fd_sc_hd__nand3_1
XFILLER_50_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3894_ _3896_/CLK _3894_/D VGND VGND VPWR VPWR _3894_/Q sky130_fd_sc_hd__dfxtp_1
X_2914_ _3712_/Q _2914_/B VGND VGND VPWR VPWR _2914_/X sky130_fd_sc_hd__or2_1
X_2845_ _2845_/A _2845_/B VGND VGND VPWR VPWR _2845_/Y sky130_fd_sc_hd__nand2_1
XFILLER_12_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2776_ _2825_/A _3744_/Q VGND VGND VPWR VPWR _2798_/A sky130_fd_sc_hd__nor2_1
X_3328_ _3363_/S VGND VGND VPWR VPWR _3827_/D sky130_fd_sc_hd__buf_12
XTAP_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3259_ _3258_/X _3811_/Q _3263_/S VGND VGND VPWR VPWR _3811_/D sky130_fd_sc_hd__mux2_1
XFILLER_73_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_26 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_211 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2630_ _3683_/Q VGND VGND VPWR VPWR _3498_/B sky130_fd_sc_hd__inv_2
X_2561_ _2682_/A _3057_/B _3058_/B VGND VGND VPWR VPWR _2561_/Y sky130_fd_sc_hd__o21ai_2
X_2492_ _2549_/B _3121_/A _2491_/Y _2762_/B VGND VGND VPWR VPWR _2492_/X sky130_fd_sc_hd__a22o_1
XFILLER_4_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3113_ _3113_/A _3128_/B _3113_/C _3113_/D VGND VGND VPWR VPWR _3113_/X sky130_fd_sc_hd__or4_1
X_3044_ _3044_/A _3044_/B VGND VGND VPWR VPWR _3044_/Y sky130_fd_sc_hd__nand2_1
XFILLER_82_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3877_ _3877_/CLK _3877_/D VGND VGND VPWR VPWR _3877_/Q sky130_fd_sc_hd__dfxtp_1
X_2828_ _3099_/B _2824_/Y _2724_/Y VGND VGND VPWR VPWR _2828_/Y sky130_fd_sc_hd__o21ai_1
X_2759_ _2759_/A _2759_/B _2759_/C VGND VGND VPWR VPWR _2759_/X sky130_fd_sc_hd__or3_1
XFILLER_48_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_214 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3800_ _3837_/CLK _3800_/D VGND VGND VPWR VPWR _3800_/Q sky130_fd_sc_hd__dfxtp_1
X_3731_ _3733_/CLK _3731_/D VGND VGND VPWR VPWR _3731_/Q sky130_fd_sc_hd__dfxtp_1
X_1992_ _1992_/A _3743_/Q VGND VGND VPWR VPWR _1993_/B sky130_fd_sc_hd__nand2_1
XFILLER_9_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3662_ _3748_/CLK _3662_/D VGND VGND VPWR VPWR _3662_/Q sky130_fd_sc_hd__dfxtp_1
X_3593_ _3900_/Q _3594_/A VGND VGND VPWR VPWR _3595_/A sky130_fd_sc_hd__or2_1
X_2613_ _2611_/X _2612_/Y _3049_/B VGND VGND VPWR VPWR _2613_/X sky130_fd_sc_hd__a21o_1
X_2544_ _2113_/A _2185_/A _3755_/Q _2782_/A VGND VGND VPWR VPWR _2544_/X sky130_fd_sc_hd__a31o_1
X_2475_ _3099_/B _2475_/B VGND VGND VPWR VPWR _2476_/A sky130_fd_sc_hd__nor2_1
XFILLER_55_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3027_ _3027_/A VGND VGND VPWR VPWR _3028_/B sky130_fd_sc_hd__inv_2
XFILLER_1_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2260_ _3830_/Q _3121_/B _3827_/Q VGND VGND VPWR VPWR _2260_/Y sky130_fd_sc_hd__o21ai_1
X_2191_ _2182_/Y _2183_/Y _2190_/X VGND VGND VPWR VPWR _3628_/D sky130_fd_sc_hd__a21o_1
XFILLER_65_412 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_42 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_320 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1975_ _3736_/Q VGND VGND VPWR VPWR _1976_/B sky130_fd_sc_hd__inv_2
XFILLER_60_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3714_ _3865_/CLK _3714_/D VGND VGND VPWR VPWR _3714_/Q sky130_fd_sc_hd__dfxtp_1
X_3645_ _3848_/CLK _3645_/D VGND VGND VPWR VPWR _3645_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_20_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3576_ _3572_/X _3574_/X _3575_/Y _3896_/Q _3577_/A VGND VGND VPWR VPWR _3896_/D
+ sky130_fd_sc_hd__a32o_1
X_2527_ _3761_/Q _3058_/B VGND VGND VPWR VPWR _2527_/X sky130_fd_sc_hd__or2_2
X_2458_ _2540_/B input5/X VGND VGND VPWR VPWR _2459_/A sky130_fd_sc_hd__nand2_1
X_2389_ _2395_/A _3017_/C _2386_/X _3555_/A VGND VGND VPWR VPWR _2389_/Y sky130_fd_sc_hd__a31oi_1
XFILLER_56_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_26 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_172 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_51 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_257 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_423 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_91 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3430_ _3672_/Q _3606_/B _3390_/Y VGND VGND VPWR VPWR _3430_/X sky130_fd_sc_hd__o21a_1
X_3361_ _3860_/Q _2255_/X _3363_/S VGND VGND VPWR VPWR _3860_/D sky130_fd_sc_hd__mux2_1
XTAP_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2312_ _3099_/B _2796_/B _3032_/B VGND VGND VPWR VPWR _2312_/Y sky130_fd_sc_hd__o21ai_1
XTAP_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3292_ _3553_/A _3292_/B _3368_/A VGND VGND VPWR VPWR _3293_/A sky130_fd_sc_hd__or3b_1
XTAP_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2243_ _3652_/Q _3649_/Q _3826_/Q VGND VGND VPWR VPWR _2243_/X sky130_fd_sc_hd__mux2_1
X_2174_ _2174_/A _2825_/A VGND VGND VPWR VPWR _2175_/A sky130_fd_sc_hd__nand2_1
XFILLER_65_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_323 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_194 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_17 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1958_ _3724_/Q _3725_/Q VGND VGND VPWR VPWR _2749_/A sky130_fd_sc_hd__nand2_4
X_1889_ _2825_/A VGND VGND VPWR VPWR _2797_/A sky130_fd_sc_hd__inv_2
X_3628_ _3628_/CLK _3628_/D VGND VGND VPWR VPWR _3628_/Q sky130_fd_sc_hd__dfxtp_2
X_3559_ _3559_/A _3559_/B VGND VGND VPWR VPWR _3559_/Y sky130_fd_sc_hd__nor2_1
XFILLER_29_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_183 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_242 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_223 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2930_ _2930_/A _3022_/A VGND VGND VPWR VPWR _2930_/X sky130_fd_sc_hd__or2_1
XFILLER_62_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2861_ input47/X _3049_/B _2860_/Y VGND VGND VPWR VPWR _2861_/Y sky130_fd_sc_hd__o21ai_1
X_1812_ _1812_/A _1812_/B VGND VGND VPWR VPWR _1903_/A sky130_fd_sc_hd__nand2_1
X_2792_ _3122_/B _2792_/B VGND VGND VPWR VPWR _2792_/Y sky130_fd_sc_hd__nor2_1
XFILLER_7_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_371 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3413_ _3407_/X _3409_/X _3412_/Y _3869_/Q _3577_/A VGND VGND VPWR VPWR _3869_/D
+ sky130_fd_sc_hd__a32o_1
X_3344_ _3843_/Q _2221_/X _3827_/D VGND VGND VPWR VPWR _3843_/D sky130_fd_sc_hd__mux2_1
XTAP_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3275_ _3279_/B _3275_/B VGND VGND VPWR VPWR _3291_/A sky130_fd_sc_hd__nor2_1
XTAP_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2226_ _2225_/X _3644_/Q _2244_/S VGND VGND VPWR VPWR _3644_/D sky130_fd_sc_hd__mux2_1
XTAP_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2157_ _2723_/A _2449_/A _2157_/C VGND VGND VPWR VPWR _2157_/Y sky130_fd_sc_hd__nor3_1
XFILLER_53_212 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2088_ _2668_/A _3734_/Q VGND VGND VPWR VPWR _2104_/B sky130_fd_sc_hd__nand2_1
XFILLER_13_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3060_ _3060_/A _3060_/B VGND VGND VPWR VPWR _3060_/Y sky130_fd_sc_hd__nand2_1
XFILLER_82_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2011_ _2094_/B VGND VGND VPWR VPWR _2100_/A sky130_fd_sc_hd__inv_2
XFILLER_50_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3893_ _3897_/CLK _3893_/D VGND VGND VPWR VPWR _3893_/Q sky130_fd_sc_hd__dfxtp_1
X_2913_ _3756_/Q _3834_/Q _3623_/A VGND VGND VPWR VPWR _2913_/X sky130_fd_sc_hd__mux2_1
X_2844_ _2564_/Y _2839_/Y _2721_/B _2841_/Y _2843_/X VGND VGND VPWR VPWR _2845_/B
+ sky130_fd_sc_hd__o2111ai_1
X_2775_ _3565_/B _2796_/B VGND VGND VPWR VPWR _2775_/Y sky130_fd_sc_hd__nor2_1
X_3327_ _3327_/A _3327_/B VGND VGND VPWR VPWR _3363_/S sky130_fd_sc_hd__nor2_8
XTAP_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3258_ _3270_/A _3850_/Q VGND VGND VPWR VPWR _3258_/X sky130_fd_sc_hd__and2_1
XFILLER_37_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2209_ _3635_/Q _3632_/Q _3362_/S VGND VGND VPWR VPWR _2209_/X sky130_fd_sc_hd__mux2_1
XFILLER_66_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3189_ _3189_/A _3189_/B VGND VGND VPWR VPWR _3193_/A sky130_fd_sc_hd__nand2_1
XFILLER_81_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_13_i_clk clkbuf_leaf_9_i_clk/A VGND VGND VPWR VPWR _3784_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_49_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_28_i_clk clkbuf_2_2__f_i_clk/X VGND VGND VPWR VPWR _3877_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_64_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2560_ _3757_/Q VGND VGND VPWR VPWR _2682_/A sky130_fd_sc_hd__inv_2
X_2491_ _3414_/B _2796_/B VGND VGND VPWR VPWR _2491_/Y sky130_fd_sc_hd__nor2_1
X_3112_ _3109_/Y _3190_/B _3127_/A _3111_/Y VGND VGND VPWR VPWR _3748_/D sky130_fd_sc_hd__a31oi_1
X_3043_ _3725_/Q _2157_/C _2447_/B VGND VGND VPWR VPWR _3044_/A sky130_fd_sc_hd__o21ai_1
XFILLER_48_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_362 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3876_ _3877_/CLK _3876_/D VGND VGND VPWR VPWR _3876_/Q sky130_fd_sc_hd__dfxtp_1
X_2827_ _2826_/X _3122_/A _3049_/B VGND VGND VPWR VPWR _2835_/C sky130_fd_sc_hd__a21oi_1
X_2758_ _3044_/B _2750_/X _2751_/Y _2757_/Y VGND VGND VPWR VPWR _2759_/C sky130_fd_sc_hd__a211o_1
X_2689_ _3516_/B _2559_/Y _2688_/Y VGND VGND VPWR VPWR _3686_/D sky130_fd_sc_hd__o21ai_1
XFILLER_48_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_112 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_207 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3730_ _3737_/CLK _3730_/D VGND VGND VPWR VPWR _3730_/Q sky130_fd_sc_hd__dfxtp_2
X_1991_ _2676_/B VGND VGND VPWR VPWR _1992_/A sky130_fd_sc_hd__inv_2
XFILLER_13_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3661_ _3900_/CLK _3661_/D VGND VGND VPWR VPWR _3661_/Q sky130_fd_sc_hd__dfxtp_2
X_3592_ _3899_/Q _3580_/Y _3590_/X _3591_/X VGND VGND VPWR VPWR _3899_/D sky130_fd_sc_hd__a22o_1
X_2612_ _3121_/A _2993_/A VGND VGND VPWR VPWR _2612_/Y sky130_fd_sc_hd__nand2_1
XFILLER_62_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2543_ _2608_/A _3676_/Q _2839_/A _3725_/Q _2856_/B VGND VGND VPWR VPWR _2547_/C
+ sky130_fd_sc_hd__a32o_1
X_2474_ _3745_/Q VGND VGND VPWR VPWR _2475_/B sky130_fd_sc_hd__inv_2
XFILLER_36_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3026_ _3026_/A _3058_/B VGND VGND VPWR VPWR _3027_/A sky130_fd_sc_hd__nand2_1
X_3859_ _3860_/CLK _3859_/D VGND VGND VPWR VPWR _3859_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_50_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_218 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_13 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2190_ _2863_/B _2190_/B VGND VGND VPWR VPWR _2190_/X sky130_fd_sc_hd__or2_1
XFILLER_65_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1974_ _2083_/A _2083_/B _1974_/C VGND VGND VPWR VPWR _2006_/B sky130_fd_sc_hd__nand3_2
X_3713_ _3775_/CLK _3713_/D VGND VGND VPWR VPWR _3713_/Q sky130_fd_sc_hd__dfxtp_1
X_3644_ _3848_/CLK _3644_/D VGND VGND VPWR VPWR _3644_/Q sky130_fd_sc_hd__dfxtp_1
Xclkbuf_2_2__f_i_clk clkbuf_0_i_clk/X VGND VGND VPWR VPWR clkbuf_2_2__f_i_clk/X sky130_fd_sc_hd__clkbuf_16
X_3575_ _3077_/C _3553_/A _3411_/A VGND VGND VPWR VPWR _3575_/Y sky130_fd_sc_hd__a21oi_1
X_2526_ _2904_/A _3057_/B _3058_/B VGND VGND VPWR VPWR _2526_/Y sky130_fd_sc_hd__o21ai_2
X_2457_ _2457_/A VGND VGND VPWR VPWR _2460_/A sky130_fd_sc_hd__inv_2
XFILLER_68_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2388_ _3571_/A VGND VGND VPWR VPWR _3555_/A sky130_fd_sc_hd__inv_4
XFILLER_56_424 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3009_ _3831_/Q _3753_/Q _3009_/S VGND VGND VPWR VPWR _3009_/X sky130_fd_sc_hd__mux2_1
XFILLER_24_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_376 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_435 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_438 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3360_ _3859_/Q _2253_/X _3363_/S VGND VGND VPWR VPWR _3859_/D sky130_fd_sc_hd__mux2_1
XTAP_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2311_ _2829_/A VGND VGND VPWR VPWR _3032_/B sky130_fd_sc_hd__inv_2
XTAP_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3291_ _3291_/A _3291_/B VGND VGND VPWR VPWR _3368_/A sky130_fd_sc_hd__nand2_1
XTAP_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2242_ _2241_/X _3652_/Q _2244_/S VGND VGND VPWR VPWR _3652_/D sky130_fd_sc_hd__mux2_1
XFILLER_25_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2173_ _3699_/Q _2165_/A _3199_/B _2338_/A VGND VGND VPWR VPWR _2176_/A sky130_fd_sc_hd__a31o_1
XFILLER_38_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1957_ _2624_/A _3731_/Q VGND VGND VPWR VPWR _1963_/A sky130_fd_sc_hd__xnor2_1
X_1888_ _2130_/A _2187_/B VGND VGND VPWR VPWR _2721_/B sky130_fd_sc_hd__nand2_8
X_3627_ _3785_/CLK _3627_/D VGND VGND VPWR VPWR _3627_/Q sky130_fd_sc_hd__dfxtp_2
X_3558_ _3893_/Q _3577_/A _3554_/X _3557_/Y VGND VGND VPWR VPWR _3893_/D sky130_fd_sc_hd__a22o_1
XFILLER_0_228 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2509_ _2839_/A _2762_/B _3672_/Q _2003_/A _3121_/A VGND VGND VPWR VPWR _2509_/X
+ sky130_fd_sc_hd__a32o_1
X_3489_ _3568_/A _3489_/B VGND VGND VPWR VPWR _3489_/X sky130_fd_sc_hd__or2_1
XFILLER_56_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_254 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_427 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_235 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2860_ _3049_/B _2860_/B VGND VGND VPWR VPWR _2860_/Y sky130_fd_sc_hd__nand2_1
X_1811_ _3786_/Q _3746_/Q VGND VGND VPWR VPWR _1812_/B sky130_fd_sc_hd__nand2_1
X_2791_ _2721_/B _2676_/Y _2408_/A _2787_/X _2790_/Y VGND VGND VPWR VPWR _2792_/B
+ sky130_fd_sc_hd__o221a_1
XFILLER_7_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3412_ _3414_/B _3553_/A _3577_/A VGND VGND VPWR VPWR _3412_/Y sky130_fd_sc_hd__a21oi_1
XTAP_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3343_ _3842_/Q _2219_/X _3827_/D VGND VGND VPWR VPWR _3842_/D sky130_fd_sc_hd__mux2_1
XTAP_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3274_ _3865_/Q VGND VGND VPWR VPWR _3279_/B sky130_fd_sc_hd__inv_2
XTAP_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2225_ _3643_/Q _3640_/Q _3362_/S VGND VGND VPWR VPWR _2225_/X sky130_fd_sc_hd__mux2_1
XTAP_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2156_ _3783_/Q _3119_/A VGND VGND VPWR VPWR _2157_/C sky130_fd_sc_hd__nor2_1
X_2087_ input6/X VGND VGND VPWR VPWR _2668_/A sky130_fd_sc_hd__inv_2
XFILLER_53_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_290 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2989_ _2987_/Y _2960_/X _2988_/Y VGND VGND VPWR VPWR _3736_/D sky130_fd_sc_hd__o21ai_1
XFILLER_29_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2010_ _3004_/A _3742_/Q VGND VGND VPWR VPWR _2094_/B sky130_fd_sc_hd__xor2_1
X_2912_ _2910_/X _2901_/Y _3022_/B _2911_/X VGND VGND VPWR VPWR _3711_/D sky130_fd_sc_hd__o211a_1
X_3892_ _3896_/CLK _3892_/D VGND VGND VPWR VPWR _3892_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_31_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2843_ _1932_/A _3088_/B _2766_/A _2832_/A _2842_/Y VGND VGND VPWR VPWR _2843_/X
+ sky130_fd_sc_hd__o2111a_1
X_2774_ _3694_/Q VGND VGND VPWR VPWR _3565_/B sky130_fd_sc_hd__clkinv_2
X_3326_ _3325_/X _3362_/S _3326_/S VGND VGND VPWR VPWR _3826_/D sky130_fd_sc_hd__mux2_1
XTAP_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3257_ _3256_/X _3810_/Q _3263_/S VGND VGND VPWR VPWR _3810_/D sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_9_i_clk clkbuf_leaf_9_i_clk/A VGND VGND VPWR VPWR _3839_/CLK sky130_fd_sc_hd__clkbuf_16
XTAP_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2208_ _2207_/X _3635_/Q _2244_/S VGND VGND VPWR VPWR _3635_/D sky130_fd_sc_hd__mux2_1
X_3188_ _3188_/A _3188_/B VGND VGND VPWR VPWR _3189_/B sky130_fd_sc_hd__nand2_1
X_2139_ _2139_/A _3661_/Q VGND VGND VPWR VPWR _3186_/B sky130_fd_sc_hd__nand2_1
XFILLER_81_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_430 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_282 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2490_ _3669_/Q VGND VGND VPWR VPWR _3414_/B sky130_fd_sc_hd__inv_2
XFILLER_57_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3111_ _3748_/Q _3127_/A _3022_/B VGND VGND VPWR VPWR _3111_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_67_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3042_ _3042_/A _3042_/B VGND VGND VPWR VPWR _3046_/A sky130_fd_sc_hd__nand2_1
XFILLER_55_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3875_ _3890_/CLK _3875_/D VGND VGND VPWR VPWR _3875_/Q sky130_fd_sc_hd__dfxtp_1
X_2826_ _2824_/Y _2825_/A _2777_/A _2825_/Y VGND VGND VPWR VPWR _2826_/X sky130_fd_sc_hd__a211o_1
X_2757_ _3032_/C _2753_/Y _2756_/X VGND VGND VPWR VPWR _2757_/Y sky130_fd_sc_hd__a21oi_1
X_2688_ _2678_/Y _2687_/X _2559_/Y VGND VGND VPWR VPWR _2688_/Y sky130_fd_sc_hd__o21ai_1
XTAP_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3309_ _3555_/A _3695_/Q _3329_/A _3895_/Q _3308_/Y VGND VGND VPWR VPWR _3309_/X
+ sky130_fd_sc_hd__o32a_1
XFILLER_58_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_116 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1990_ _2888_/A _2676_/B VGND VGND VPWR VPWR _1996_/C sky130_fd_sc_hd__nand2_1
XFILLER_20_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_399 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3660_ _3849_/CLK _3660_/D VGND VGND VPWR VPWR _3660_/Q sky130_fd_sc_hd__dfxtp_1
X_3591_ _3406_/Y _3606_/B _3697_/Q VGND VGND VPWR VPWR _3591_/X sky130_fd_sc_hd__mux2_1
X_2611_ _3486_/B _2720_/B _2796_/B VGND VGND VPWR VPWR _2611_/X sky130_fd_sc_hd__or3_1
X_2542_ _2542_/A _3122_/B VGND VGND VPWR VPWR _2547_/B sky130_fd_sc_hd__and2_1
XFILLER_55_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2473_ input5/X _3121_/A _2472_/Y _2762_/B VGND VGND VPWR VPWR _2473_/X sky130_fd_sc_hd__a22o_1
XFILLER_68_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3025_ _3138_/B _3025_/B VGND VGND VPWR VPWR _3028_/A sky130_fd_sc_hd__nand2_1
XFILLER_51_311 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_12_i_clk clkbuf_leaf_9_i_clk/A VGND VGND VPWR VPWR _3830_/CLK sky130_fd_sc_hd__clkbuf_16
X_3858_ _3862_/CLK _3858_/D VGND VGND VPWR VPWR _3858_/Q sky130_fd_sc_hd__dfxtp_1
X_3789_ _3846_/CLK _3789_/D VGND VGND VPWR VPWR _3789_/Q sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_27_i_clk clkbuf_2_2__f_i_clk/X VGND VGND VPWR VPWR _3886_/CLK sky130_fd_sc_hd__clkbuf_16
X_2809_ _2460_/B _2438_/Y _2798_/Y _2808_/Y VGND VGND VPWR VPWR _2809_/Y sky130_fd_sc_hd__a22oi_1
XFILLER_3_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_99 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_174 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1973_ _1973_/A _1973_/B VGND VGND VPWR VPWR _1974_/C sky130_fd_sc_hd__nor2_1
X_3712_ _3905_/CLK _3712_/D VGND VGND VPWR VPWR _3712_/Q sky130_fd_sc_hd__dfxtp_1
X_3643_ _3846_/CLK _3643_/D VGND VGND VPWR VPWR _3643_/Q sky130_fd_sc_hd__dfxtp_1
X_3574_ _3585_/A _3574_/B VGND VGND VPWR VPWR _3574_/X sky130_fd_sc_hd__or2_1
X_2525_ _3753_/Q VGND VGND VPWR VPWR _2904_/A sky130_fd_sc_hd__inv_2
X_2456_ _3199_/A _3121_/A VGND VGND VPWR VPWR _2456_/Y sky130_fd_sc_hd__nand2_1
XFILLER_68_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2387_ _3663_/Q VGND VGND VPWR VPWR _3571_/A sky130_fd_sc_hd__buf_4
XFILLER_56_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3008_ _1992_/A _3002_/A _3007_/Y VGND VGND VPWR VPWR _3743_/D sky130_fd_sc_hd__o21ai_1
XFILLER_24_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_152 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_355 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3290_ _3552_/S _3893_/Q _3286_/X _3568_/A VGND VGND VPWR VPWR _3290_/Y sky130_fd_sc_hd__a211oi_1
X_2310_ _3099_/B _3745_/Q VGND VGND VPWR VPWR _2829_/A sky130_fd_sc_hd__nor2_1
XTAP_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2241_ _3651_/Q _3648_/Q _3362_/S VGND VGND VPWR VPWR _2241_/X sky130_fd_sc_hd__mux2_1
XFILLER_38_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2172_ _1880_/Y _2437_/B _3106_/B VGND VGND VPWR VPWR _2338_/A sky130_fd_sc_hd__a21o_1
XFILLER_65_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1956_ _2610_/A _3730_/Q VGND VGND VPWR VPWR _2104_/A sky130_fd_sc_hd__nand2_1
X_1887_ _1938_/B _2439_/B VGND VGND VPWR VPWR _2130_/A sky130_fd_sc_hd__and2_2
X_3626_ _3865_/CLK _3626_/D VGND VGND VPWR VPWR _3626_/Q sky130_fd_sc_hd__dfxtp_1
X_3557_ _3406_/Y _3557_/B _3557_/C VGND VGND VPWR VPWR _3557_/Y sky130_fd_sc_hd__nand3b_1
X_2508_ _2507_/X _3671_/Q _2793_/A VGND VGND VPWR VPWR _3671_/D sky130_fd_sc_hd__mux2_1
X_3488_ _3881_/Q _3878_/Q _3552_/S VGND VGND VPWR VPWR _3489_/B sky130_fd_sc_hd__mux2_1
X_2439_ _2439_/A _2439_/B _2439_/C VGND VGND VPWR VPWR _2439_/X sky130_fd_sc_hd__and3_1
XFILLER_71_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_211 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_266 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1810_ _1847_/A _3824_/Q VGND VGND VPWR VPWR _1812_/A sky130_fd_sc_hd__nand2_1
XFILLER_30_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2790_ _2790_/A _3044_/B VGND VGND VPWR VPWR _2790_/Y sky130_fd_sc_hd__nand2_1
XFILLER_11_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3411_ _3411_/A VGND VGND VPWR VPWR _3577_/A sky130_fd_sc_hd__clkbuf_16
X_3342_ _3841_/Q _2217_/X _3827_/D VGND VGND VPWR VPWR _3841_/D sky130_fd_sc_hd__mux2_1
XTAP_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3273_ _3273_/A VGND VGND VPWR VPWR _3322_/A sky130_fd_sc_hd__inv_2
XTAP_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2224_ _2223_/X _3643_/Q _2244_/S VGND VGND VPWR VPWR _3643_/D sky130_fd_sc_hd__mux2_1
XTAP_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2155_ _3099_/B _3745_/Q VGND VGND VPWR VPWR _2449_/A sky130_fd_sc_hd__nand2_2
XFILLER_26_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2086_ _2091_/A _2086_/B VGND VGND VPWR VPWR _2095_/A sky130_fd_sc_hd__nand2_1
XFILLER_21_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2988_ _3002_/A _3736_/Q VGND VGND VPWR VPWR _2988_/Y sky130_fd_sc_hd__nand2_1
X_1939_ _2185_/A _2118_/B VGND VGND VPWR VPWR _3184_/A sky130_fd_sc_hd__nor2_4
X_3609_ _3605_/Y _3902_/Q _3606_/X _3608_/X VGND VGND VPWR VPWR _3902_/D sky130_fd_sc_hd__a22o_1
XFILLER_76_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_100 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2911_ _3711_/Q _2914_/B VGND VGND VPWR VPWR _2911_/X sky130_fd_sc_hd__or2_1
X_3891_ _3896_/CLK _3891_/D VGND VGND VPWR VPWR _3891_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_31_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2842_ _2842_/A _2842_/B _2842_/C VGND VGND VPWR VPWR _2842_/Y sky130_fd_sc_hd__nor3_1
X_2773_ _2772_/X _3693_/Q _2803_/S VGND VGND VPWR VPWR _3693_/D sky130_fd_sc_hd__mux2_1
XFILLER_7_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3325_ _3552_/S _3319_/A _3324_/Y _3307_/A VGND VGND VPWR VPWR _3325_/X sky130_fd_sc_hd__a22o_1
XTAP_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3256_ _3270_/A _3843_/Q VGND VGND VPWR VPWR _3256_/X sky130_fd_sc_hd__and2_1
XTAP_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2207_ _3634_/Q _3631_/Q _3362_/S VGND VGND VPWR VPWR _2207_/X sky130_fd_sc_hd__mux2_1
XTAP_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3187_ _3187_/A _3187_/B VGND VGND VPWR VPWR _3189_/A sky130_fd_sc_hd__nand2_1
XFILLER_81_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2138_ _2138_/A _3131_/B _2138_/C VGND VGND VPWR VPWR _2138_/Y sky130_fd_sc_hd__nand3_1
XFILLER_26_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2069_ _2069_/A _2069_/B VGND VGND VPWR VPWR _2073_/A sky130_fd_sc_hd__nand2_1
XFILLER_81_375 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3110_ _3141_/S VGND VGND VPWR VPWR _3127_/A sky130_fd_sc_hd__inv_2
XFILLER_67_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3041_ _3118_/A _3556_/A VGND VGND VPWR VPWR _3042_/B sky130_fd_sc_hd__nand2_1
XFILLER_67_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3874_ _3874_/CLK _3874_/D VGND VGND VPWR VPWR _3874_/Q sky130_fd_sc_hd__dfxtp_1
X_2825_ _2825_/A _3032_/A VGND VGND VPWR VPWR _2825_/Y sky130_fd_sc_hd__nor2_1
X_2756_ _2478_/A _2767_/B _2785_/A VGND VGND VPWR VPWR _2756_/X sky130_fd_sc_hd__a21bo_1
X_2687_ _3743_/Q _2600_/A _2679_/X _2680_/X _2686_/X VGND VGND VPWR VPWR _2687_/X
+ sky130_fd_sc_hd__a2111o_1
XTAP_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3308_ _3589_/B _3552_/S VGND VGND VPWR VPWR _3308_/Y sky130_fd_sc_hd__nand2_1
XFILLER_58_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3239_ _3801_/Q _3263_/S _3238_/X VGND VGND VPWR VPWR _3801_/D sky130_fd_sc_hd__a21o_1
XTAP_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_397 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_94 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_8_i_clk clkbuf_leaf_9_i_clk/A VGND VGND VPWR VPWR _3706_/CLK sky130_fd_sc_hd__clkbuf_16
X_3590_ _3899_/Q _3584_/A _3589_/Y _3580_/A VGND VGND VPWR VPWR _3590_/X sky130_fd_sc_hd__a22o_1
X_2610_ _2610_/A _2668_/B _2721_/B VGND VGND VPWR VPWR _2610_/X sky130_fd_sc_hd__or3_1
X_2541_ _2839_/A _2762_/B _3676_/Q _2654_/A _3121_/A VGND VGND VPWR VPWR _2542_/A
+ sky130_fd_sc_hd__a32o_1
X_2472_ _2472_/A _2796_/B VGND VGND VPWR VPWR _2472_/Y sky130_fd_sc_hd__nor2_1
X_3024_ _3024_/A _3024_/B VGND VGND VPWR VPWR _3025_/B sky130_fd_sc_hd__nand2_1
XFILLER_51_323 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3857_ _3860_/CLK _3857_/D VGND VGND VPWR VPWR _3857_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_50_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3788_ _3846_/CLK _3788_/D VGND VGND VPWR VPWR _3788_/Q sky130_fd_sc_hd__dfxtp_1
X_2808_ _3077_/C _2796_/B _2825_/A VGND VGND VPWR VPWR _2808_/Y sky130_fd_sc_hd__o21ai_1
X_2739_ _2600_/A _2738_/Y _2832_/B VGND VGND VPWR VPWR _2739_/X sky130_fd_sc_hd__o21a_1
XFILLER_59_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_437 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_320 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_117 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1972_ _3734_/Q _3735_/Q VGND VGND VPWR VPWR _1973_/B sky130_fd_sc_hd__nand2_1
XFILLER_60_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3711_ _3905_/CLK _3711_/D VGND VGND VPWR VPWR _3711_/Q sky130_fd_sc_hd__dfxtp_1
X_3642_ _3846_/CLK _3642_/D VGND VGND VPWR VPWR _3642_/Q sky130_fd_sc_hd__dfxtp_1
X_3573_ _3895_/Q _3892_/Q _3607_/A VGND VGND VPWR VPWR _3574_/B sky130_fd_sc_hd__mux2_1
X_2524_ _2624_/A _3121_/A _2523_/Y _2762_/B VGND VGND VPWR VPWR _2524_/X sky130_fd_sc_hd__a22o_1
X_2455_ _2455_/A VGND VGND VPWR VPWR _3121_/A sky130_fd_sc_hd__clkbuf_16
X_2386_ _2386_/A _3039_/B _2453_/B _3046_/B VGND VGND VPWR VPWR _2386_/X sky130_fd_sc_hd__and4_1
XFILLER_68_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3007_ _3007_/A _3743_/Q VGND VGND VPWR VPWR _3007_/Y sky130_fd_sc_hd__nand2_1
XFILLER_64_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_301 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_172 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_378 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_11_i_clk clkbuf_leaf_9_i_clk/A VGND VGND VPWR VPWR _3846_/CLK sky130_fd_sc_hd__clkbuf_16
X_2240_ _2239_/X _3651_/Q _2244_/S VGND VGND VPWR VPWR _3651_/D sky130_fd_sc_hd__mux2_1
X_2171_ _2171_/A VGND VGND VPWR VPWR _3106_/B sky130_fd_sc_hd__inv_2
XFILLER_65_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_26_i_clk clkbuf_2_2__f_i_clk/X VGND VGND VPWR VPWR _3882_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_80_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1955_ _1955_/A VGND VGND VPWR VPWR _2610_/A sky130_fd_sc_hd__inv_2
X_1886_ _2109_/A VGND VGND VPWR VPWR _1938_/B sky130_fd_sc_hd__inv_2
X_3625_ _2693_/Y _3623_/X _3620_/Y _3022_/B _3624_/X VGND VGND VPWR VPWR _3905_/D
+ sky130_fd_sc_hd__o311a_1
X_3556_ _3556_/A _3689_/Q VGND VGND VPWR VPWR _3557_/C sky130_fd_sc_hd__nand2_1
X_2507_ _3122_/B _2505_/X _2608_/A _2504_/Y _2506_/X VGND VGND VPWR VPWR _2507_/X
+ sky130_fd_sc_hd__a221o_1
X_3487_ _3556_/A _3678_/Q _3486_/Y _3406_/Y VGND VGND VPWR VPWR _3487_/X sky130_fd_sc_hd__a211o_1
X_2438_ _2761_/A _2438_/B VGND VGND VPWR VPWR _2438_/Y sky130_fd_sc_hd__nor2_1
X_2369_ _3627_/Q _2369_/B VGND VGND VPWR VPWR _3054_/B sky130_fd_sc_hd__nor2_1
XFILLER_56_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_256 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3410_ _3579_/B VGND VGND VPWR VPWR _3411_/A sky130_fd_sc_hd__buf_6
X_3341_ _3840_/Q _2215_/X _3827_/D VGND VGND VPWR VPWR _3840_/D sky130_fd_sc_hd__mux2_1
XTAP_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3272_ _3863_/Q _3327_/B VGND VGND VPWR VPWR _3273_/A sky130_fd_sc_hd__nor2_1
XTAP_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2223_ _3642_/Q _3639_/Q _3362_/S VGND VGND VPWR VPWR _2223_/X sky130_fd_sc_hd__mux2_1
XTAP_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2154_ _2154_/A _2399_/A VGND VGND VPWR VPWR _2182_/A sky130_fd_sc_hd__nand2_1
X_2085_ input7/X _3735_/Q VGND VGND VPWR VPWR _2086_/B sky130_fd_sc_hd__xnor2_1
XFILLER_34_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_134 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2987_ input8/X VGND VGND VPWR VPWR _2987_/Y sky130_fd_sc_hd__inv_2
XFILLER_21_189 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1938_ _2114_/A _1938_/B VGND VGND VPWR VPWR _2118_/B sky130_fd_sc_hd__nand2_2
X_1869_ _2187_/B _3036_/A _3748_/Q VGND VGND VPWR VPWR _1870_/A sky130_fd_sc_hd__and3_1
X_3608_ _3589_/B _3613_/B _3391_/Y VGND VGND VPWR VPWR _3608_/X sky130_fd_sc_hd__a21o_1
X_3539_ _3535_/X _3537_/X _3538_/X _3890_/Q _3577_/A VGND VGND VPWR VPWR _3890_/D
+ sky130_fd_sc_hd__a32o_1
XFILLER_17_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_344 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2910_ _3755_/Q _3833_/Q _3623_/A VGND VGND VPWR VPWR _2910_/X sky130_fd_sc_hd__mux2_1
X_3890_ _3890_/CLK _3890_/D VGND VGND VPWR VPWR _3890_/Q sky130_fd_sc_hd__dfxtp_1
X_2841_ _3202_/A _2841_/B VGND VGND VPWR VPWR _2841_/Y sky130_fd_sc_hd__nand2_1
XFILLER_78_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2772_ _2721_/B _2670_/Y _2763_/X _2771_/X VGND VGND VPWR VPWR _2772_/X sky130_fd_sc_hd__o211a_1
XFILLER_7_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3324_ _1842_/B _3367_/B _3302_/Y VGND VGND VPWR VPWR _3324_/Y sky130_fd_sc_hd__o21ai_1
XTAP_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3255_ _3254_/X _3809_/Q _3263_/S VGND VGND VPWR VPWR _3809_/D sky130_fd_sc_hd__mux2_1
XTAP_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2206_ _2205_/X _3634_/Q _2244_/S VGND VGND VPWR VPWR _3634_/D sky130_fd_sc_hd__mux2_1
XTAP_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3186_ _3186_/A _3186_/B _3186_/C VGND VGND VPWR VPWR _3187_/B sky130_fd_sc_hd__and3_1
XFILLER_26_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2137_ _3184_/A _2134_/Y _2136_/Y VGND VGND VPWR VPWR _2138_/C sky130_fd_sc_hd__o21ai_1
X_2068_ _2066_/Y _3740_/Q _2069_/B VGND VGND VPWR VPWR _2102_/B sky130_fd_sc_hd__o21ai_1
XFILLER_81_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_218 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3040_ _3571_/A VGND VGND VPWR VPWR _3556_/A sky130_fd_sc_hd__clkbuf_16
XFILLER_48_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3873_ _3874_/CLK _3873_/D VGND VGND VPWR VPWR _3873_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_31_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2824_ _2839_/A _3697_/Q VGND VGND VPWR VPWR _2824_/Y sky130_fd_sc_hd__nand2_1
X_2755_ _3184_/A _3053_/A _2755_/C VGND VGND VPWR VPWR _2785_/A sky130_fd_sc_hd__nor3_1
X_2686_ _3773_/Q _3058_/B _2683_/X _2684_/X _2685_/Y VGND VGND VPWR VPWR _2686_/X
+ sky130_fd_sc_hd__o221a_1
X_3307_ _3307_/A _3367_/B VGND VGND VPWR VPWR _3329_/A sky130_fd_sc_hd__nand2_1
XTAP_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3238_ _3244_/A _3834_/Q _3244_/C VGND VGND VPWR VPWR _3238_/X sky130_fd_sc_hd__and3_1
XTAP_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3169_ input46/X _3779_/Q _3173_/S VGND VGND VPWR VPWR _3779_/D sky130_fd_sc_hd__mux2_1
XFILLER_54_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_199 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2540_ _2863_/A _2540_/B _3121_/A VGND VGND VPWR VPWR _2547_/A sky130_fd_sc_hd__and3_1
X_2471_ _3667_/Q VGND VGND VPWR VPWR _2472_/A sky130_fd_sc_hd__inv_2
X_3023_ _3023_/A _3023_/B VGND VGND VPWR VPWR _3024_/A sky130_fd_sc_hd__nor2_1
XFILLER_55_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_140 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3856_ _3862_/CLK _3856_/D VGND VGND VPWR VPWR _3856_/Q sky130_fd_sc_hd__dfxtp_1
X_3787_ _3846_/CLK _3787_/D VGND VGND VPWR VPWR _3787_/Q sky130_fd_sc_hd__dfxtp_1
X_2807_ _3032_/A _2600_/A _3032_/C _2806_/Y _2756_/X VGND VGND VPWR VPWR _2807_/X
+ sky130_fd_sc_hd__a221o_1
X_2738_ _3778_/Q _2782_/A _2856_/A VGND VGND VPWR VPWR _2738_/Y sky130_fd_sc_hd__a21oi_1
X_2669_ _3121_/A _3004_/A VGND VGND VPWR VPWR _2670_/A sky130_fd_sc_hd__nand2_1
XFILLER_59_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_387 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1971_ _3732_/Q _3733_/Q VGND VGND VPWR VPWR _1973_/A sky130_fd_sc_hd__nand2_1
X_3710_ _3905_/CLK _3710_/D VGND VGND VPWR VPWR _3710_/Q sky130_fd_sc_hd__dfxtp_1
X_3641_ _3846_/CLK _3641_/D VGND VGND VPWR VPWR _3641_/Q sky130_fd_sc_hd__dfxtp_1
X_3572_ _3556_/A _3692_/Q _3571_/Y _3406_/Y VGND VGND VPWR VPWR _3572_/X sky130_fd_sc_hd__a211o_1
XFILLER_60_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2523_ _3444_/B _2796_/B VGND VGND VPWR VPWR _2523_/Y sky130_fd_sc_hd__nor2_1
X_2454_ _3121_/B _3049_/B VGND VGND VPWR VPWR _3199_/A sky130_fd_sc_hd__nor2_1
X_2385_ _2385_/A VGND VGND VPWR VPWR _3039_/B sky130_fd_sc_hd__inv_2
XFILLER_68_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput1 i_qspi_dat[0] VGND VGND VPWR VPWR input1/X sky130_fd_sc_hd__dlymetal6s2s_1
X_3006_ _3004_/Y _2960_/X _3005_/Y VGND VGND VPWR VPWR _3742_/D sky130_fd_sc_hd__o21ai_1
XFILLER_51_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3839_ _3839_/CLK _3839_/D VGND VGND VPWR VPWR _3839_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_10_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_7_i_clk clkbuf_leaf_9_i_clk/A VGND VGND VPWR VPWR _3838_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_70_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_313 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2170_ _2779_/B _2170_/B VGND VGND VPWR VPWR _2171_/A sky130_fd_sc_hd__nor2_1
XFILLER_38_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_290 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1954_ _2370_/B _2362_/B VGND VGND VPWR VPWR _3054_/A sky130_fd_sc_hd__nand2_1
X_1885_ _3748_/Q _3747_/Q VGND VGND VPWR VPWR _2109_/A sky130_fd_sc_hd__nand2_1
X_3624_ _3905_/Q _3624_/B VGND VGND VPWR VPWR _3624_/X sky130_fd_sc_hd__or2_1
X_3555_ _3555_/A _3692_/Q VGND VGND VPWR VPWR _3557_/B sky130_fd_sc_hd__nand2_1
XFILLER_0_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3486_ _3559_/A _3486_/B VGND VGND VPWR VPWR _3486_/Y sky130_fd_sc_hd__nor2_1
X_2506_ _3758_/Q _2782_/A _2480_/Y _3728_/Q VGND VGND VPWR VPWR _2506_/X sky130_fd_sc_hd__a22o_1
X_2437_ _2437_/A _2437_/B _3106_/A _2457_/A VGND VGND VPWR VPWR _2817_/A sky130_fd_sc_hd__or4_1
X_2368_ _2368_/A _2368_/B _2368_/C VGND VGND VPWR VPWR _3138_/B sky130_fd_sc_hd__nand3_2
XFILLER_56_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2299_ _2856_/B _3013_/A VGND VGND VPWR VPWR _2766_/A sky130_fd_sc_hd__nor2_2
XFILLER_56_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3340_ _3839_/Q _2213_/X _3827_/D VGND VGND VPWR VPWR _3839_/D sky130_fd_sc_hd__mux2_1
XTAP_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3271_ _3270_/X _3817_/Q _3366_/S VGND VGND VPWR VPWR _3817_/D sky130_fd_sc_hd__mux2_1
XTAP_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2222_ _2221_/X _3642_/Q _2244_/S VGND VGND VPWR VPWR _3642_/D sky130_fd_sc_hd__mux2_1
XFILLER_23_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2153_ _3044_/B _3020_/A VGND VGND VPWR VPWR _2399_/A sky130_fd_sc_hd__nor2_1
XFILLER_38_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2084_ _2084_/A _2084_/B VGND VGND VPWR VPWR _2091_/A sky130_fd_sc_hd__nor2_1
XFILLER_21_146 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2986_ _2984_/Y _2960_/X _2985_/Y VGND VGND VPWR VPWR _3735_/D sky130_fd_sc_hd__o21ai_1
X_1937_ _3829_/Q _3058_/B _1936_/Y VGND VGND VPWR VPWR _1937_/Y sky130_fd_sc_hd__o21ai_1
X_1868_ _2185_/A VGND VGND VPWR VPWR _2187_/B sky130_fd_sc_hd__inv_16
X_3607_ _3607_/A _3902_/Q VGND VGND VPWR VPWR _3613_/B sky130_fd_sc_hd__nor2_1
X_3538_ _3690_/Q _3606_/B _3390_/Y VGND VGND VPWR VPWR _3538_/X sky130_fd_sc_hd__o21a_1
X_3469_ _3556_/A _3675_/Q _3468_/Y _3406_/Y VGND VGND VPWR VPWR _3469_/X sky130_fd_sc_hd__a211o_1
XFILLER_17_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_246 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_10_i_clk clkbuf_leaf_9_i_clk/A VGND VGND VPWR VPWR _3842_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_12_146 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_25_i_clk clkbuf_2_2__f_i_clk/X VGND VGND VPWR VPWR _3727_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_4_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2840_ _2839_/Y _2825_/A _2825_/Y VGND VGND VPWR VPWR _2841_/B sky130_fd_sc_hd__a21oi_1
XFILLER_31_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2771_ _3044_/B _2765_/X _2770_/X _3131_/C VGND VGND VPWR VPWR _2771_/X sky130_fd_sc_hd__a22o_1
XTAP_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3323_ _3320_/X _3825_/Q _3326_/S VGND VGND VPWR VPWR _3825_/D sky130_fd_sc_hd__mux2_1
XTAP_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3254_ _3270_/A _3842_/Q VGND VGND VPWR VPWR _3254_/X sky130_fd_sc_hd__and2_1
XTAP_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2205_ _3633_/Q _3630_/Q _3362_/S VGND VGND VPWR VPWR _2205_/X sky130_fd_sc_hd__mux2_1
XTAP_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3185_ _3185_/A _3185_/B VGND VGND VPWR VPWR _3187_/A sky130_fd_sc_hd__nand2_1
XFILLER_81_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2136_ _3132_/B _2949_/A VGND VGND VPWR VPWR _2136_/Y sky130_fd_sc_hd__nand2_1
X_2067_ _3001_/A _3741_/Q VGND VGND VPWR VPWR _2069_/B sky130_fd_sc_hd__xnor2_1
XFILLER_22_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2969_ _2567_/A _2960_/X _2968_/Y VGND VGND VPWR VPWR _3727_/D sky130_fd_sc_hd__o21ai_1
XFILLER_78_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_68_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3872_ _3874_/CLK _3872_/D VGND VGND VPWR VPWR _3872_/Q sky130_fd_sc_hd__dfxtp_1
X_2823_ _2823_/A _2823_/B _2823_/C VGND VGND VPWR VPWR _2845_/A sky130_fd_sc_hd__nor3_2
X_2754_ _2754_/A _3032_/C VGND VGND VPWR VPWR _2767_/B sky130_fd_sc_hd__nor2_1
X_2685_ _2842_/C _2888_/A _2856_/A VGND VGND VPWR VPWR _2685_/Y sky130_fd_sc_hd__a21oi_1
XTAP_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3306_ _3306_/A _3306_/B VGND VGND VPWR VPWR _3306_/Y sky130_fd_sc_hd__nor2_1
XFILLER_58_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3237_ _3800_/Q _3263_/S _3236_/X VGND VGND VPWR VPWR _3800_/D sky130_fd_sc_hd__a21o_1
XTAP_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3168_ input45/X _3778_/Q _3173_/S VGND VGND VPWR VPWR _3778_/D sky130_fd_sc_hd__mux2_1
X_2119_ _2876_/S VGND VGND VPWR VPWR _2752_/B sky130_fd_sc_hd__clkinv_4
X_3099_ _3099_/A _3099_/B VGND VGND VPWR VPWR _3099_/Y sky130_fd_sc_hd__nand2_1
XFILLER_13_77 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_145 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_212 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_50 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2470_ _2469_/X _3666_/Q _2793_/A VGND VGND VPWR VPWR _3666_/D sky130_fd_sc_hd__mux2_1
X_3022_ _3022_/A _3022_/B VGND VGND VPWR VPWR _3746_/D sky130_fd_sc_hd__nand2_1
XFILLER_48_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_152 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3855_ _3861_/CLK _3855_/D VGND VGND VPWR VPWR _3855_/Q sky130_fd_sc_hd__dfxtp_1
X_3786_ _3865_/CLK _3786_/D VGND VGND VPWR VPWR _3786_/Q sky130_fd_sc_hd__dfxtp_1
X_2806_ _3783_/Q _3058_/B _2842_/B VGND VGND VPWR VPWR _2806_/Y sky130_fd_sc_hd__o21ai_1
X_2737_ _3099_/B _2736_/C _3044_/B VGND VGND VPWR VPWR _2737_/Y sky130_fd_sc_hd__o21ai_1
X_2668_ _2668_/A _2668_/B _2721_/B VGND VGND VPWR VPWR _2673_/B sky130_fd_sc_hd__or3_1
X_2599_ _3738_/Q VGND VGND VPWR VPWR _2880_/A sky130_fd_sc_hd__inv_2
XFILLER_59_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_255 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1970_ _1970_/A _1970_/B VGND VGND VPWR VPWR _2083_/B sky130_fd_sc_hd__nor2_1
XFILLER_60_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3640_ _3839_/CLK _3640_/D VGND VGND VPWR VPWR _3640_/Q sky130_fd_sc_hd__dfxtp_1
X_3571_ _3571_/A _3571_/B VGND VGND VPWR VPWR _3571_/Y sky130_fd_sc_hd__nor2_1
X_2522_ _3674_/Q VGND VGND VPWR VPWR _3444_/B sky130_fd_sc_hd__inv_2
XFILLER_53_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2453_ _2453_/A _2453_/B _3056_/A VGND VGND VPWR VPWR _2816_/C sky130_fd_sc_hd__and3_1
X_2384_ _2384_/A _2392_/A VGND VGND VPWR VPWR _2386_/A sky130_fd_sc_hd__and2_1
XFILLER_68_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput2 i_qspi_dat[1] VGND VGND VPWR VPWR input2/X sky130_fd_sc_hd__dlymetal6s2s_1
X_3005_ _3007_/A _3742_/Q VGND VGND VPWR VPWR _3005_/Y sky130_fd_sc_hd__nand2_1
XFILLER_36_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3838_ _3838_/CLK _3838_/D VGND VGND VPWR VPWR _3838_/Q sky130_fd_sc_hd__dfxtp_1
X_3769_ _3774_/CLK _3769_/D VGND VGND VPWR VPWR _3769_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_59_200 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_130 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_453 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1953_ _3627_/Q _2183_/B _3122_/B _1884_/X _1952_/Y VGND VGND VPWR VPWR _3627_/D
+ sky130_fd_sc_hd__a221o_1
X_1884_ _3700_/Q _2762_/B _2179_/B VGND VGND VPWR VPWR _1884_/X sky130_fd_sc_hd__a21o_1
X_3623_ _3623_/A _3836_/Q VGND VGND VPWR VPWR _3623_/X sky130_fd_sc_hd__and2_1
X_3554_ _3568_/A _3552_/X _3553_/Y _3390_/Y VGND VGND VPWR VPWR _3554_/X sky130_fd_sc_hd__o211a_1
X_3485_ _3481_/X _3483_/X _3484_/Y _3881_/Q _3577_/A VGND VGND VPWR VPWR _3881_/D
+ sky130_fd_sc_hd__a32o_1
X_2505_ _2577_/B _3121_/A _2504_/Y _2762_/B VGND VGND VPWR VPWR _2505_/X sky130_fd_sc_hd__a22o_1
X_2436_ _2742_/B _2436_/B VGND VGND VPWR VPWR _2457_/A sky130_fd_sc_hd__nand2_1
X_2367_ _2367_/A _2453_/B VGND VGND VPWR VPWR _2368_/C sky130_fd_sc_hd__nor2_1
X_2298_ _3020_/A _2298_/B VGND VGND VPWR VPWR _2300_/B sky130_fd_sc_hd__nor2_1
XFILLER_56_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_88 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_291 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_13 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3270_ _3270_/A _3856_/Q VGND VGND VPWR VPWR _3270_/X sky130_fd_sc_hd__and2_1
XTAP_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2221_ _3641_/Q _3638_/Q _3362_/S VGND VGND VPWR VPWR _2221_/X sky130_fd_sc_hd__mux2_1
XTAP_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2152_ _3049_/B _2721_/B VGND VGND VPWR VPWR _3020_/A sky130_fd_sc_hd__nand2_4
X_2083_ _2083_/A _2083_/B _3732_/Q VGND VGND VPWR VPWR _2084_/B sky130_fd_sc_hd__nand3_1
XFILLER_53_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2985_ _3002_/A _3735_/Q VGND VGND VPWR VPWR _2985_/Y sky130_fd_sc_hd__nand2_1
X_1936_ _2328_/A _1936_/B VGND VGND VPWR VPWR _1936_/Y sky130_fd_sc_hd__nand2_1
X_1867_ _1867_/A VGND VGND VPWR VPWR _2183_/B sky130_fd_sc_hd__inv_2
Xinput60 i_wb_we VGND VGND VPWR VPWR _1875_/A sky130_fd_sc_hd__dlymetal6s2s_1
Xclkbuf_leaf_6_i_clk clkbuf_leaf_9_i_clk/A VGND VGND VPWR VPWR _3837_/CLK sky130_fd_sc_hd__clkbuf_16
X_3606_ _3615_/B _3606_/B VGND VGND VPWR VPWR _3606_/X sky130_fd_sc_hd__and2_1
X_3537_ _3568_/A _3537_/B VGND VGND VPWR VPWR _3537_/X sky130_fd_sc_hd__or2_1
X_3468_ _3559_/A _3468_/B VGND VGND VPWR VPWR _3468_/Y sky130_fd_sc_hd__nor2_1
XFILLER_76_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3399_ _3666_/Q _3391_/Y _3398_/Y VGND VGND VPWR VPWR _3399_/X sky130_fd_sc_hd__a21o_1
X_2419_ _3044_/B _2449_/A VGND VGND VPWR VPWR _2419_/Y sky130_fd_sc_hd__nand2_1
XFILLER_29_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_258 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2770_ _2767_/Y _2785_/A _2769_/Y _3742_/Q _2856_/B VGND VGND VPWR VPWR _2770_/X
+ sky130_fd_sc_hd__a32o_1
XFILLER_7_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3322_ _3322_/A _3382_/B VGND VGND VPWR VPWR _3326_/S sky130_fd_sc_hd__nand2_1
XTAP_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3253_ _3252_/X _3808_/Q _3263_/S VGND VGND VPWR VPWR _3808_/D sky130_fd_sc_hd__mux2_1
XTAP_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2204_ _2203_/X _3633_/Q _2244_/S VGND VGND VPWR VPWR _3633_/D sky130_fd_sc_hd__mux2_1
XTAP_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3184_ _3184_/A _3188_/B VGND VGND VPWR VPWR _3185_/B sky130_fd_sc_hd__nand2_1
X_2135_ _3184_/A VGND VGND VPWR VPWR _3132_/B sky130_fd_sc_hd__clkinv_2
XFILLER_66_386 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2066_ _2640_/B VGND VGND VPWR VPWR _2066_/Y sky130_fd_sc_hd__inv_2
XFILLER_34_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2968_ _3002_/A _3727_/Q VGND VGND VPWR VPWR _2968_/Y sky130_fd_sc_hd__nand2_1
X_1919_ _2259_/B _2122_/A VGND VGND VPWR VPWR _2120_/A sky130_fd_sc_hd__and2_2
X_2899_ _2899_/A _2899_/B _2899_/C VGND VGND VPWR VPWR _3619_/B sky130_fd_sc_hd__nor3_1
XFILLER_1_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_117 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_228 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3871_ _3874_/CLK _3871_/D VGND VGND VPWR VPWR _3871_/Q sky130_fd_sc_hd__dfxtp_1
X_2822_ _2822_/A _3072_/A _2822_/C _2822_/D VGND VGND VPWR VPWR _2823_/C sky130_fd_sc_hd__or4_1
XFILLER_31_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2753_ _3779_/Q _3058_/B _2842_/B VGND VGND VPWR VPWR _2753_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_8_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2684_ _3904_/Q _2842_/A _2833_/B VGND VGND VPWR VPWR _2684_/X sky130_fd_sc_hd__a21o_1
XTAP_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3305_ _3304_/X _3821_/Q _3306_/B VGND VGND VPWR VPWR _3821_/D sky130_fd_sc_hd__mux2_1
XTAP_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3236_ _3244_/A _3833_/Q _3244_/C VGND VGND VPWR VPWR _3236_/X sky130_fd_sc_hd__and3_1
XTAP_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3167_ input44/X _3777_/Q _3173_/S VGND VGND VPWR VPWR _3777_/D sky130_fd_sc_hd__mux2_1
XFILLER_66_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_24_i_clk clkbuf_2_2__f_i_clk/X VGND VGND VPWR VPWR _3687_/CLK sky130_fd_sc_hd__clkbuf_16
X_2118_ _2187_/B _2118_/B VGND VGND VPWR VPWR _2876_/S sky130_fd_sc_hd__nor2_8
X_3098_ _3131_/A _3186_/B _3131_/C VGND VGND VPWR VPWR _3098_/X sky130_fd_sc_hd__and3_1
XFILLER_81_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2049_ _2749_/A _2044_/A _3728_/Q VGND VGND VPWR VPWR _2059_/A sky130_fd_sc_hd__o21bai_1
XFILLER_80_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_39_i_clk _3628_/CLK VGND VGND VPWR VPWR _3759_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_10_404 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_164 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_62 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3021_ _2475_/B _3165_/S _2825_/A _3197_/A VGND VGND VPWR VPWR _3745_/D sky130_fd_sc_hd__o2bb2a_1
XFILLER_36_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3854_ _3861_/CLK _3854_/D VGND VGND VPWR VPWR _3854_/Q sky130_fd_sc_hd__dfxtp_1
X_2805_ _3053_/C VGND VGND VPWR VPWR _3131_/A sky130_fd_sc_hd__inv_2
X_3785_ _3785_/CLK _3785_/D VGND VGND VPWR VPWR _3785_/Q sky130_fd_sc_hd__dfxtp_1
X_2736_ _3122_/B _2825_/A _2736_/C VGND VGND VPWR VPWR _2742_/C sky130_fd_sc_hd__and3_1
X_2667_ _3742_/Q _2600_/A _2660_/X _2666_/X VGND VGND VPWR VPWR _2673_/A sky130_fd_sc_hd__a211oi_1
X_2598_ _3681_/Q VGND VGND VPWR VPWR _3486_/B sky130_fd_sc_hd__inv_2
X_3219_ _3218_/X _3792_/Q _3263_/S VGND VGND VPWR VPWR _3792_/D sky130_fd_sc_hd__mux2_1
XFILLER_39_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_267 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3570_ _3566_/X _3568_/X _3569_/Y _3895_/Q _3577_/A VGND VGND VPWR VPWR _3895_/D
+ sky130_fd_sc_hd__a32o_1
X_2521_ _2520_/X _3673_/Q _2793_/A VGND VGND VPWR VPWR _3673_/D sky130_fd_sc_hd__mux2_1
X_2452_ _2821_/C _3090_/B _2821_/B VGND VGND VPWR VPWR _2462_/A sky130_fd_sc_hd__and3_1
XFILLER_46_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2383_ _2782_/A _2854_/C VGND VGND VPWR VPWR _2392_/A sky130_fd_sc_hd__nor2_1
XFILLER_68_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput3 i_qspi_dat[2] VGND VGND VPWR VPWR input3/X sky130_fd_sc_hd__dlymetal6s2s_1
X_3004_ _3004_/A VGND VGND VPWR VPWR _3004_/Y sky130_fd_sc_hd__inv_2
XFILLER_36_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3837_ _3837_/CLK _3837_/D VGND VGND VPWR VPWR _3837_/Q sky130_fd_sc_hd__dfxtp_1
X_3768_ _3774_/CLK _3768_/D VGND VGND VPWR VPWR _3768_/Q sky130_fd_sc_hd__dfxtp_1
X_2719_ _2719_/A VGND VGND VPWR VPWR _3122_/A sky130_fd_sc_hd__inv_2
X_3699_ _3774_/CLK _3699_/D VGND VGND VPWR VPWR _3699_/Q sky130_fd_sc_hd__dfxtp_4
XFILLER_59_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_370 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_76_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_432 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_465 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1952_ _2721_/B _2164_/B _1951_/Y VGND VGND VPWR VPWR _1952_/Y sky130_fd_sc_hd__o21ai_1
X_1883_ _2825_/A _1880_/Y _1890_/A VGND VGND VPWR VPWR _2179_/B sky130_fd_sc_hd__o21a_1
X_3622_ _2682_/Y _3617_/X _3620_/Y _3022_/B _3621_/X VGND VGND VPWR VPWR _3904_/D
+ sky130_fd_sc_hd__o311a_1
X_3553_ _3553_/A _3559_/B VGND VGND VPWR VPWR _3553_/Y sky130_fd_sc_hd__nand2_1
X_2504_ _3426_/B _2796_/B VGND VGND VPWR VPWR _2504_/Y sky130_fd_sc_hd__nor2_1
X_3484_ _3486_/B _3553_/A _3411_/A VGND VGND VPWR VPWR _3484_/Y sky130_fd_sc_hd__a21oi_1
X_2435_ _2435_/A _2438_/B VGND VGND VPWR VPWR _2742_/B sky130_fd_sc_hd__nor2_1
X_2366_ _3131_/B VGND VGND VPWR VPWR _3053_/A sky130_fd_sc_hd__inv_2
XFILLER_2_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2297_ _3131_/B _3046_/B VGND VGND VPWR VPWR _2298_/B sky130_fd_sc_hd__nand2_1
XFILLER_56_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_432 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_23 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2220_ _2219_/X _3641_/Q _2244_/S VGND VGND VPWR VPWR _3641_/D sky130_fd_sc_hd__mux2_1
XFILLER_30_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2151_ _3011_/B VGND VGND VPWR VPWR _3044_/B sky130_fd_sc_hd__inv_4
XFILLER_19_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2082_ _3733_/Q VGND VGND VPWR VPWR _2084_/A sky130_fd_sc_hd__inv_2
XFILLER_46_270 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2984_ input7/X VGND VGND VPWR VPWR _2984_/Y sky130_fd_sc_hd__inv_2
X_1935_ _2328_/B VGND VGND VPWR VPWR _1936_/B sky130_fd_sc_hd__inv_2
X_1866_ _3618_/A _2842_/C VGND VGND VPWR VPWR _1867_/A sky130_fd_sc_hd__nor2_1
Xinput50 i_wb_data[30] VGND VGND VPWR VPWR input50/X sky130_fd_sc_hd__clkbuf_1
X_3605_ _3611_/C _3379_/B _3615_/B VGND VGND VPWR VPWR _3605_/Y sky130_fd_sc_hd__o21ai_1
X_3536_ _3889_/Q _3886_/Q _3607_/A VGND VGND VPWR VPWR _3537_/B sky130_fd_sc_hd__mux2_1
X_3467_ _3463_/X _3465_/X _3466_/Y _3878_/Q _3577_/A VGND VGND VPWR VPWR _3878_/D
+ sky130_fd_sc_hd__a32o_1
X_3398_ _3398_/A _3402_/B VGND VGND VPWR VPWR _3398_/Y sky130_fd_sc_hd__nand2_1
X_2418_ _2850_/A _3060_/A _1936_/Y VGND VGND VPWR VPWR _2418_/X sky130_fd_sc_hd__a21bo_1
X_2349_ _3717_/Q VGND VGND VPWR VPWR _2929_/A sky130_fd_sc_hd__inv_2
XFILLER_29_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_398 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3321_ _3379_/B _3379_/A VGND VGND VPWR VPWR _3382_/B sky130_fd_sc_hd__nand2_1
XTAP_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3252_ _3270_/A _3841_/Q VGND VGND VPWR VPWR _3252_/X sky130_fd_sc_hd__and2_1
XTAP_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3183_ _3206_/C _3188_/B _3175_/Y _3182_/Y VGND VGND VPWR VPWR _3185_/A sky130_fd_sc_hd__o211ai_1
X_2203_ _3632_/Q _3629_/Q _3362_/S VGND VGND VPWR VPWR _2203_/X sky130_fd_sc_hd__mux2_1
XFILLER_78_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2134_ _2443_/A _2134_/B VGND VGND VPWR VPWR _2134_/Y sky130_fd_sc_hd__nand2_1
XFILLER_66_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_398 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2065_ _2065_/A _2065_/B VGND VGND VPWR VPWR _2098_/A sky130_fd_sc_hd__nor2_1
XFILLER_34_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2967_ _2039_/C _2960_/X _2966_/Y VGND VGND VPWR VPWR _3726_/D sky130_fd_sc_hd__o21ai_1
X_1918_ _2439_/C _2259_/B VGND VGND VPWR VPWR _3009_/S sky130_fd_sc_hd__nand2_4
X_2898_ _3204_/A _3084_/A _3034_/B _3174_/A VGND VGND VPWR VPWR _2899_/C sky130_fd_sc_hd__or4_1
X_1849_ _3722_/Q _3714_/Q _3195_/C VGND VGND VPWR VPWR _3626_/D sky130_fd_sc_hd__or3_1
XFILLER_78_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3519_ _3568_/A _3519_/B VGND VGND VPWR VPWR _3519_/X sky130_fd_sc_hd__or2_1
XFILLER_76_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_346 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_5_i_clk clkbuf_leaf_9_i_clk/A VGND VGND VPWR VPWR _3905_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_16_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3870_ _3874_/CLK _3870_/D VGND VGND VPWR VPWR _3870_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_31_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2821_ _2821_/A _2821_/B _2821_/C VGND VGND VPWR VPWR _2822_/D sky130_fd_sc_hd__nand3_1
XFILLER_76_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2752_ _3058_/B _2752_/B VGND VGND VPWR VPWR _2842_/B sky130_fd_sc_hd__nand2_1
XFILLER_8_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2683_ _2876_/S _2681_/Y _2682_/Y VGND VGND VPWR VPWR _2683_/X sky130_fd_sc_hd__a21o_1
X_3304_ _3589_/B _3552_/S _3894_/Q _3303_/X _3307_/A VGND VGND VPWR VPWR _3304_/X
+ sky130_fd_sc_hd__a32o_1
XTAP_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3235_ _3799_/Q _3263_/S _3234_/X VGND VGND VPWR VPWR _3799_/D sky130_fd_sc_hd__a21o_1
XTAP_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3166_ input43/X _3776_/Q _3173_/S VGND VGND VPWR VPWR _3776_/D sky130_fd_sc_hd__mux2_1
XFILLER_66_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3097_ _3093_/Y _2293_/A _2832_/B _3096_/Y VGND VGND VPWR VPWR _3097_/X sky130_fd_sc_hd__a31o_1
XFILLER_54_335 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2117_ _3023_/B VGND VGND VPWR VPWR _2713_/A sky130_fd_sc_hd__inv_2
X_2048_ _2048_/A _2048_/B VGND VGND VPWR VPWR _2053_/A sky130_fd_sc_hd__nor2_1
XFILLER_10_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_176 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3020_ _3020_/A VGND VGND VPWR VPWR _3197_/A sky130_fd_sc_hd__clkinv_2
XFILLER_36_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3853_ _3861_/CLK _3853_/D VGND VGND VPWR VPWR _3853_/Q sky130_fd_sc_hd__dfxtp_1
X_2804_ _3696_/Q VGND VGND VPWR VPWR _3077_/C sky130_fd_sc_hd__clkinv_2
X_3784_ _3784_/CLK _3784_/D VGND VGND VPWR VPWR _3784_/Q sky130_fd_sc_hd__dfxtp_2
X_2735_ _2839_/A _3546_/B VGND VGND VPWR VPWR _2736_/C sky130_fd_sc_hd__nand2_1
X_2666_ _3772_/Q _3058_/B _2662_/Y _2663_/X _2665_/X VGND VGND VPWR VPWR _2666_/X
+ sky130_fd_sc_hd__o2111a_1
X_2597_ _3480_/B _2559_/Y _2596_/X VGND VGND VPWR VPWR _3680_/D sky130_fd_sc_hd__o21ai_1
XFILLER_74_408 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3218_ _3849_/Q _3270_/A _3229_/A _3706_/Q VGND VGND VPWR VPWR _3218_/X sky130_fd_sc_hd__a22o_1
XFILLER_39_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_430 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3149_ input56/X _3759_/Q _3165_/S VGND VGND VPWR VPWR _3759_/D sky130_fd_sc_hd__mux2_1
XFILLER_82_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_346 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_73 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2520_ _3122_/B _2516_/X _2608_/A _2515_/Y _2519_/X VGND VGND VPWR VPWR _2520_/X
+ sky130_fd_sc_hd__a221o_1
X_2451_ _2451_/A _3044_/B VGND VGND VPWR VPWR _2821_/B sky130_fd_sc_hd__nand2_1
Xclkbuf_leaf_23_i_clk clkbuf_2_3__f_i_clk/X VGND VGND VPWR VPWR _3725_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_39_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2382_ _3056_/A VGND VGND VPWR VPWR _2854_/C sky130_fd_sc_hd__inv_2
Xclkbuf_leaf_38_i_clk _3628_/CLK VGND VGND VPWR VPWR _3865_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_56_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput4 i_qspi_dat[3] VGND VGND VPWR VPWR input4/X sky130_fd_sc_hd__dlymetal6s2s_1
X_3003_ _3001_/Y _2960_/X _3002_/Y VGND VGND VPWR VPWR _3741_/D sky130_fd_sc_hd__o21ai_1
XFILLER_36_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3905_ _3905_/CLK _3905_/D VGND VGND VPWR VPWR _3905_/Q sky130_fd_sc_hd__dfxtp_1
X_3836_ _3838_/CLK _3836_/D VGND VGND VPWR VPWR _3836_/Q sky130_fd_sc_hd__dfxtp_1
X_3767_ _3767_/CLK _3767_/D VGND VGND VPWR VPWR _3767_/Q sky130_fd_sc_hd__dfxtp_1
X_2718_ _2459_/A _2777_/A _2797_/A _2369_/B VGND VGND VPWR VPWR _2719_/A sky130_fd_sc_hd__a31o_1
X_3698_ _3900_/CLK _3698_/D VGND VGND VPWR VPWR _3698_/Q sky130_fd_sc_hd__dfxtp_1
X_2649_ _3771_/Q VGND VGND VPWR VPWR _2681_/A sky130_fd_sc_hd__inv_2
XFILLER_59_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_408 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1951_ _2139_/A _1915_/X _1950_/X _3784_/Q VGND VGND VPWR VPWR _1951_/Y sky130_fd_sc_hd__o31ai_1
X_1882_ _2435_/A _2427_/B VGND VGND VPWR VPWR _1890_/A sky130_fd_sc_hd__nor2_1
X_3621_ _3904_/Q _3624_/B VGND VGND VPWR VPWR _3621_/X sky130_fd_sc_hd__or2_1
X_3552_ _3892_/Q _3889_/Q _3552_/S VGND VGND VPWR VPWR _3552_/X sky130_fd_sc_hd__mux2_1
X_2503_ _3671_/Q VGND VGND VPWR VPWR _3426_/B sky130_fd_sc_hd__inv_2
X_3483_ _3568_/A _3483_/B VGND VGND VPWR VPWR _3483_/X sky130_fd_sc_hd__or2_1
X_2434_ _2434_/A VGND VGND VPWR VPWR _3106_/A sky130_fd_sc_hd__inv_2
X_2365_ _3204_/C VGND VGND VPWR VPWR _2365_/Y sky130_fd_sc_hd__inv_2
X_2296_ _2296_/A VGND VGND VPWR VPWR _3131_/C sky130_fd_sc_hd__inv_2
XFILLER_56_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3819_ _3900_/CLK _3819_/D VGND VGND VPWR VPWR _3819_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_21_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_374 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2150_ _2138_/Y _3186_/B _3188_/A VGND VGND VPWR VPWR _2154_/A sky130_fd_sc_hd__a21o_1
X_2081_ _2081_/A _2081_/B VGND VGND VPWR VPWR _2093_/A sky130_fd_sc_hd__nand2_1
XFILLER_46_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2983_ _2668_/A _2960_/X _2982_/Y VGND VGND VPWR VPWR _3734_/D sky130_fd_sc_hd__o21ai_1
X_1934_ _2477_/A _3099_/B VGND VGND VPWR VPWR _2328_/B sky130_fd_sc_hd__nand2_1
X_1865_ _3026_/A _2726_/A VGND VGND VPWR VPWR _2842_/C sky130_fd_sc_hd__nand2_8
Xinput40 i_wb_data[21] VGND VGND VPWR VPWR input40/X sky130_fd_sc_hd__clkbuf_1
Xinput51 i_wb_data[31] VGND VGND VPWR VPWR _2165_/A sky130_fd_sc_hd__buf_2
X_3604_ _3611_/C _1827_/A _3580_/A VGND VGND VPWR VPWR _3615_/B sky130_fd_sc_hd__o21a_1
X_3535_ _3556_/A _3686_/Q _3534_/X _3406_/Y VGND VGND VPWR VPWR _3535_/X sky130_fd_sc_hd__a211o_1
X_3466_ _3468_/B _3553_/A _3411_/A VGND VGND VPWR VPWR _3466_/Y sky130_fd_sc_hd__a21oi_1
X_2417_ _2417_/A _3128_/A VGND VGND VPWR VPWR _3060_/A sky130_fd_sc_hd__nor2_1
X_3397_ _3552_/S _3585_/A _3866_/Q VGND VGND VPWR VPWR _3398_/A sky130_fd_sc_hd__or3b_1
X_2348_ _3716_/Q _3715_/Q _3714_/Q VGND VGND VPWR VPWR _2350_/A sky130_fd_sc_hd__nor3_1
X_2279_ _3046_/B VGND VGND VPWR VPWR _2953_/A sky130_fd_sc_hd__inv_2
XFILLER_25_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_403 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_263 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3320_ _3318_/X _3307_/A _3319_/X VGND VGND VPWR VPWR _3320_/X sky130_fd_sc_hd__a21o_1
XFILLER_3_370 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3251_ _3250_/X _3807_/Q _3263_/S VGND VGND VPWR VPWR _3807_/D sky130_fd_sc_hd__mux2_1
XTAP_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2202_ _2201_/X _3632_/Q _2244_/S VGND VGND VPWR VPWR _3632_/D sky130_fd_sc_hd__mux2_1
XFILLER_66_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3182_ _3009_/S _3176_/Y _3181_/Y VGND VGND VPWR VPWR _3182_/Y sky130_fd_sc_hd__o21ai_1
X_2133_ _2112_/Y _2132_/X _1921_/Y VGND VGND VPWR VPWR _2138_/A sky130_fd_sc_hd__a21o_1
XFILLER_66_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2064_ _2064_/A _2064_/B VGND VGND VPWR VPWR _2065_/B sky130_fd_sc_hd__nand2_1
X_2966_ _3002_/A _3726_/Q VGND VGND VPWR VPWR _2966_/Y sky130_fd_sc_hd__nand2_1
X_2897_ _2897_/A _2897_/B VGND VGND VPWR VPWR _2899_/B sky130_fd_sc_hd__or2_1
X_1917_ _2293_/A VGND VGND VPWR VPWR _3196_/A sky130_fd_sc_hd__clkinv_2
X_1848_ _3723_/Q VGND VGND VPWR VPWR _3195_/C sky130_fd_sc_hd__inv_2
XFILLER_1_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3518_ _3886_/Q _3883_/Q _3607_/A VGND VGND VPWR VPWR _3519_/B sky130_fd_sc_hd__mux2_1
X_3449_ _3445_/X _3447_/X _3448_/X _3875_/Q _3577_/A VGND VGND VPWR VPWR _3875_/D
+ sky130_fd_sc_hd__a32o_1
XFILLER_27_34 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_322 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2820_ _2941_/A _2820_/B _2820_/C VGND VGND VPWR VPWR _2822_/C sky130_fd_sc_hd__or3_1
XFILLER_31_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2751_ _2885_/A _3011_/A _3046_/B VGND VGND VPWR VPWR _2751_/Y sky130_fd_sc_hd__o21ai_1
X_2682_ _2682_/A _2895_/B VGND VGND VPWR VPWR _2682_/Y sky130_fd_sc_hd__nor2_1
XFILLER_8_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3303_ _3565_/B _3302_/Y _3821_/Q _1835_/B VGND VGND VPWR VPWR _3303_/X sky130_fd_sc_hd__a2bb2o_1
XTAP_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3234_ _3244_/A _3832_/Q _3244_/C VGND VGND VPWR VPWR _3234_/X sky130_fd_sc_hd__and3_1
XTAP_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3165_ input42/X _3775_/Q _3165_/S VGND VGND VPWR VPWR _3775_/D sky130_fd_sc_hd__mux2_1
XFILLER_81_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3096_ _3130_/B VGND VGND VPWR VPWR _3096_/Y sky130_fd_sc_hd__inv_2
X_2116_ _3057_/B _2895_/B VGND VGND VPWR VPWR _3023_/B sky130_fd_sc_hd__nand2_2
XFILLER_81_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2047_ _2566_/A _2052_/A VGND VGND VPWR VPWR _2048_/B sky130_fd_sc_hd__nor2_1
XFILLER_54_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2949_ _2949_/A VGND VGND VPWR VPWR _2954_/A sky130_fd_sc_hd__inv_2
XFILLER_13_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_174 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3852_ _3852_/CLK _3852_/D VGND VGND VPWR VPWR _3852_/Q sky130_fd_sc_hd__dfxtp_1
X_2803_ _2802_/X _3695_/Q _2803_/S VGND VGND VPWR VPWR _3695_/D sky130_fd_sc_hd__mux2_1
X_3783_ _3830_/CLK _3783_/D VGND VGND VPWR VPWR _3783_/Q sky130_fd_sc_hd__dfxtp_1
X_2734_ _3691_/Q VGND VGND VPWR VPWR _3546_/B sky130_fd_sc_hd__inv_2
X_2665_ _3023_/B _2833_/B _2664_/Y VGND VGND VPWR VPWR _2665_/X sky130_fd_sc_hd__or3b_1
X_2596_ _2596_/A _2596_/B _2803_/S VGND VGND VPWR VPWR _2596_/X sky130_fd_sc_hd__or3_1
XFILLER_5_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3217_ _3216_/X _3791_/Q _3263_/S VGND VGND VPWR VPWR _3791_/D sky130_fd_sc_hd__mux2_1
XFILLER_67_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3148_ input55/X _3758_/Q _3165_/S VGND VGND VPWR VPWR _3758_/D sky130_fd_sc_hd__mux2_1
XFILLER_27_303 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_358 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3079_ _2423_/B _3056_/B _3186_/C _3078_/Y VGND VGND VPWR VPWR _3079_/Y sky130_fd_sc_hd__o211ai_1
XFILLER_54_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_4_i_clk clkbuf_leaf_9_i_clk/A VGND VGND VPWR VPWR _3775_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_49_43 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_325 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2450_ _3056_/B _2829_/A _2864_/A _2157_/C VGND VGND VPWR VPWR _2451_/A sky130_fd_sc_hd__a22o_1
XFILLER_5_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2381_ _3053_/B _2381_/B VGND VGND VPWR VPWR _3017_/C sky130_fd_sc_hd__nor2_1
XFILLER_68_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput5 i_wb_addr[0] VGND VGND VPWR VPWR input5/X sky130_fd_sc_hd__buf_4
X_3002_ _3002_/A _3741_/Q VGND VGND VPWR VPWR _3002_/Y sky130_fd_sc_hd__nand2_1
XFILLER_36_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_442 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3904_ _3905_/CLK _3904_/D VGND VGND VPWR VPWR _3904_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_32_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3835_ _3838_/CLK _3835_/D VGND VGND VPWR VPWR _3835_/Q sky130_fd_sc_hd__dfxtp_1
X_3766_ _3766_/CLK _3766_/D VGND VGND VPWR VPWR _3766_/Q sky130_fd_sc_hd__dfxtp_1
X_2717_ _2716_/X _2584_/Y _3689_/Q _2559_/Y VGND VGND VPWR VPWR _3689_/D sky130_fd_sc_hd__o2bb2a_1
XFILLER_10_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3697_ _3900_/CLK _3697_/D VGND VGND VPWR VPWR _3697_/Q sky130_fd_sc_hd__dfxtp_1
X_2648_ _2713_/A _2646_/Y _2647_/X VGND VGND VPWR VPWR _2648_/X sky130_fd_sc_hd__a21bo_1
X_2579_ _3766_/Q VGND VGND VPWR VPWR _2601_/A sky130_fd_sc_hd__inv_2
XFILLER_59_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_239 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1950_ _3196_/A _1921_/Y _1937_/Y _1943_/Y _1949_/Y VGND VGND VPWR VPWR _1950_/X
+ sky130_fd_sc_hd__o311a_1
X_1881_ _2174_/A VGND VGND VPWR VPWR _2427_/B sky130_fd_sc_hd__inv_2
XFILLER_41_191 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3620_ _3624_/B VGND VGND VPWR VPWR _3620_/Y sky130_fd_sc_hd__inv_2
X_3551_ _3547_/X _3549_/X _3550_/Y _3892_/Q _3577_/A VGND VGND VPWR VPWR _3892_/D
+ sky130_fd_sc_hd__a32o_1
X_2502_ _2501_/X _3670_/Q _2793_/A VGND VGND VPWR VPWR _3670_/D sky130_fd_sc_hd__mux2_1
X_3482_ _3880_/Q _3877_/Q _3552_/S VGND VGND VPWR VPWR _3483_/B sky130_fd_sc_hd__mux2_1
X_2433_ _3699_/Q _2433_/B VGND VGND VPWR VPWR _2434_/A sky130_fd_sc_hd__nor2_1
X_2364_ _2364_/A _3131_/B VGND VGND VPWR VPWR _3204_/C sky130_fd_sc_hd__nor2_1
XFILLER_29_409 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2295_ _2391_/A _3011_/B VGND VGND VPWR VPWR _2296_/A sky130_fd_sc_hd__nand2_1
XFILLER_24_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_10 _3759_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3818_ _3901_/CLK _3818_/D VGND VGND VPWR VPWR _3818_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_21_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3749_ _3766_/CLK _3749_/D VGND VGND VPWR VPWR _3749_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_79_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_55 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_88 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_22_i_clk clkbuf_2_3__f_i_clk/X VGND VGND VPWR VPWR _3736_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_30_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_37_i_clk _3628_/CLK VGND VGND VPWR VPWR _3901_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_7_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2080_ _2080_/A _3738_/Q _2080_/C VGND VGND VPWR VPWR _2081_/B sky130_fd_sc_hd__nand3_1
XFILLER_21_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2982_ _3002_/A _3734_/Q VGND VGND VPWR VPWR _2982_/Y sky130_fd_sc_hd__nand2_1
XFILLER_14_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1933_ _2729_/A _3725_/Q VGND VGND VPWR VPWR _2477_/A sky130_fd_sc_hd__nand2_1
X_3603_ _3600_/X _3901_/Q _3580_/A _3602_/X VGND VGND VPWR VPWR _3901_/D sky130_fd_sc_hd__a22o_1
Xinput30 i_wb_data[12] VGND VGND VPWR VPWR input30/X sky130_fd_sc_hd__clkbuf_1
X_1864_ _1900_/A _2185_/A VGND VGND VPWR VPWR _2726_/A sky130_fd_sc_hd__nand2_2
Xinput52 i_wb_data[3] VGND VGND VPWR VPWR input52/X sky130_fd_sc_hd__clkbuf_1
Xinput41 i_wb_data[22] VGND VGND VPWR VPWR input41/X sky130_fd_sc_hd__clkbuf_1
X_3534_ _3555_/A _3689_/Q VGND VGND VPWR VPWR _3534_/X sky130_fd_sc_hd__and2_1
X_3465_ _3568_/A _3465_/B VGND VGND VPWR VPWR _3465_/X sky130_fd_sc_hd__or2_1
X_2416_ _3113_/C _2415_/Y VGND VGND VPWR VPWR _2850_/A sky130_fd_sc_hd__nor2b_1
X_3396_ _3666_/Q _3606_/B _3866_/Q _3390_/Y _3395_/X VGND VGND VPWR VPWR _3866_/D
+ sky130_fd_sc_hd__o221a_1
X_2347_ _3721_/Q _3720_/Q _3719_/Q VGND VGND VPWR VPWR _2352_/A sky130_fd_sc_hd__or3_1
XFILLER_29_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2278_ _3016_/A _2453_/A VGND VGND VPWR VPWR _2957_/A sky130_fd_sc_hd__nand2_1
XFILLER_37_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_76 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3250_ _3270_/A _3840_/Q VGND VGND VPWR VPWR _3250_/X sky130_fd_sc_hd__and2_1
XFILLER_3_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2201_ _3631_/Q input4/X _3362_/S VGND VGND VPWR VPWR _2201_/X sky130_fd_sc_hd__mux2_1
XFILLER_66_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3181_ _3178_/Y _3179_/Y _3180_/X VGND VGND VPWR VPWR _3181_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_78_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2132_ _2132_/A _3058_/B _2132_/C VGND VGND VPWR VPWR _2132_/X sky130_fd_sc_hd__and3_1
X_2063_ _2063_/A _2063_/B VGND VGND VPWR VPWR _2064_/B sky130_fd_sc_hd__nor2_1
XFILLER_34_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2965_ _2169_/B _2960_/X _2964_/Y VGND VGND VPWR VPWR _3725_/D sky130_fd_sc_hd__o21ai_1
X_1916_ _1916_/A _2187_/B VGND VGND VPWR VPWR _2293_/A sky130_fd_sc_hd__nand2_4
X_2896_ _2896_/A _3057_/B VGND VGND VPWR VPWR _2897_/B sky130_fd_sc_hd__nand2_1
X_1847_ _1847_/A _3823_/Q VGND VGND VPWR VPWR _1847_/X sky130_fd_sc_hd__and2_1
X_3517_ _3556_/A _3683_/Q _3516_/Y _3406_/Y VGND VGND VPWR VPWR _3517_/X sky130_fd_sc_hd__a211o_1
X_3448_ _3675_/Q _3606_/B _3390_/Y VGND VGND VPWR VPWR _3448_/X sky130_fd_sc_hd__o21a_1
X_3379_ _3379_/A _3379_/B VGND VGND VPWR VPWR _3380_/A sky130_fd_sc_hd__nor2_1
XFILLER_27_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_334 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2750_ _2810_/B _2747_/B _2754_/A VGND VGND VPWR VPWR _2750_/X sky130_fd_sc_hd__a21o_1
X_2681_ _2681_/A _2681_/B VGND VGND VPWR VPWR _2681_/Y sky130_fd_sc_hd__nor2_1
X_3302_ _3367_/B _3571_/A VGND VGND VPWR VPWR _3302_/Y sky130_fd_sc_hd__nand2_1
XTAP_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3233_ _3798_/Q _3263_/S _3232_/X VGND VGND VPWR VPWR _3798_/D sky130_fd_sc_hd__a21o_1
XTAP_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3164_ input41/X _3774_/Q _3165_/S VGND VGND VPWR VPWR _3774_/D sky130_fd_sc_hd__mux2_1
X_3095_ _3196_/A _3095_/B VGND VGND VPWR VPWR _3130_/B sky130_fd_sc_hd__nand2_1
X_2115_ _2681_/B _2185_/A VGND VGND VPWR VPWR _2895_/B sky130_fd_sc_hd__nand2_4
XFILLER_66_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2046_ _2046_/A _2046_/B VGND VGND VPWR VPWR _2052_/A sky130_fd_sc_hd__nand2_1
XFILLER_10_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2948_ _2948_/A _2948_/B VGND VGND VPWR VPWR _2956_/A sky130_fd_sc_hd__nand2_1
X_2879_ _2879_/A _3739_/Q VGND VGND VPWR VPWR _2881_/C sky130_fd_sc_hd__nand2_1
XFILLER_1_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_175 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3851_ _3852_/CLK _3851_/D VGND VGND VPWR VPWR _3851_/Q sky130_fd_sc_hd__dfxtp_1
X_3782_ _3837_/CLK _3782_/D VGND VGND VPWR VPWR _3782_/Q sky130_fd_sc_hd__dfxtp_1
X_2802_ _2608_/A _2797_/B _2797_/X _2798_/Y _2801_/X VGND VGND VPWR VPWR _2802_/X
+ sky130_fd_sc_hd__a221o_1
X_2733_ _2732_/X _3690_/Q _2793_/A VGND VGND VPWR VPWR _3690_/D sky130_fd_sc_hd__mux2_1
XFILLER_8_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2664_ _2876_/S _3770_/Q VGND VGND VPWR VPWR _2664_/Y sky130_fd_sc_hd__nand2_1
X_2595_ _3480_/B _2720_/B _2796_/B _2701_/A _3122_/B VGND VGND VPWR VPWR _2596_/B
+ sky130_fd_sc_hd__o311a_1
XFILLER_59_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3216_ _3848_/Q _3270_/A _3229_/A _3705_/Q VGND VGND VPWR VPWR _3216_/X sky130_fd_sc_hd__a22o_1
X_3147_ input54/X _3757_/Q _3165_/S VGND VGND VPWR VPWR _3757_/D sky130_fd_sc_hd__mux2_1
XFILLER_27_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3078_ _3693_/Q _3077_/X _3013_/A VGND VGND VPWR VPWR _3078_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_42_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2029_ _2029_/A _2029_/B VGND VGND VPWR VPWR _2030_/B sky130_fd_sc_hd__nand2_1
XFILLER_24_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_204 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_18 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2380_ _3023_/B _2380_/B VGND VGND VPWR VPWR _2395_/A sky130_fd_sc_hd__nor2_1
XFILLER_76_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput6 i_wb_addr[10] VGND VGND VPWR VPWR input6/X sky130_fd_sc_hd__dlymetal6s2s_1
X_3001_ _3001_/A VGND VGND VPWR VPWR _3001_/Y sky130_fd_sc_hd__inv_2
XFILLER_64_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3903_ _3903_/CLK _3903_/D VGND VGND VPWR VPWR _3903_/Q sky130_fd_sc_hd__dfxtp_1
X_3834_ _3905_/CLK _3834_/D VGND VGND VPWR VPWR _3834_/Q sky130_fd_sc_hd__dfxtp_1
X_3765_ _3766_/CLK _3765_/D VGND VGND VPWR VPWR _3765_/Q sky130_fd_sc_hd__dfxtp_1
X_3696_ _3785_/CLK _3696_/D VGND VGND VPWR VPWR _3696_/Q sky130_fd_sc_hd__dfxtp_2
X_2716_ _2721_/B _2612_/Y _2708_/Y _2715_/X VGND VGND VPWR VPWR _2716_/X sky130_fd_sc_hd__o211a_1
X_2647_ _3755_/Q _2895_/B _3711_/Q _3057_/B VGND VGND VPWR VPWR _2647_/X sky130_fd_sc_hd__o22a_1
X_2578_ _3758_/Q VGND VGND VPWR VPWR _2693_/A sky130_fd_sc_hd__inv_2
XFILLER_67_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_295 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_207 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1880_ _3699_/Q _2437_/A VGND VGND VPWR VPWR _1880_/Y sky130_fd_sc_hd__nor2_1
XFILLER_41_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3550_ _2746_/A _3553_/A _3411_/A VGND VGND VPWR VPWR _3550_/Y sky130_fd_sc_hd__a21oi_1
X_2501_ _3122_/B _2497_/X _2498_/X _3204_/B _2500_/X VGND VGND VPWR VPWR _2501_/X
+ sky130_fd_sc_hd__a2111o_1
X_3481_ _3556_/A _3677_/Q _3480_/Y _3406_/Y VGND VGND VPWR VPWR _3481_/X sky130_fd_sc_hd__a211o_1
X_2432_ _2820_/B _3022_/A _2815_/B _2817_/B VGND VGND VPWR VPWR _2442_/A sky130_fd_sc_hd__and4b_1
X_2363_ _3188_/B VGND VGND VPWR VPWR _3076_/B sky130_fd_sc_hd__clkinv_2
X_2294_ _2381_/B _3016_/B VGND VGND VPWR VPWR _3053_/D sky130_fd_sc_hd__nand2b_1
XFILLER_2_94 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_3_i_clk clkbuf_leaf_9_i_clk/A VGND VGND VPWR VPWR _3774_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_20_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_11 _3699_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3817_ _3862_/CLK _3817_/D VGND VGND VPWR VPWR _3817_/Q sky130_fd_sc_hd__dfxtp_1
X_3748_ _3748_/CLK _3748_/D VGND VGND VPWR VPWR _3748_/Q sky130_fd_sc_hd__dfxtp_1
X_3679_ _3687_/CLK _3679_/D VGND VGND VPWR VPWR _3679_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_28_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2981_ _2655_/A _2960_/X _2980_/Y VGND VGND VPWR VPWR _3733_/D sky130_fd_sc_hd__o21ai_1
XFILLER_14_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1932_ _1932_/A VGND VGND VPWR VPWR _2328_/A sky130_fd_sc_hd__inv_2
X_1863_ _2142_/B _2122_/A VGND VGND VPWR VPWR _1900_/A sky130_fd_sc_hd__and2_2
Xinput20 i_wb_addr[5] VGND VGND VPWR VPWR _2003_/A sky130_fd_sc_hd__clkbuf_2
X_3602_ _3589_/B _3588_/A _3376_/Y _3377_/Y _3601_/Y VGND VGND VPWR VPWR _3602_/X
+ sky130_fd_sc_hd__a41o_1
Xinput31 i_wb_data[13] VGND VGND VPWR VPWR input31/X sky130_fd_sc_hd__clkbuf_1
Xinput53 i_wb_data[4] VGND VGND VPWR VPWR input53/X sky130_fd_sc_hd__clkbuf_1
Xinput42 i_wb_data[23] VGND VGND VPWR VPWR input42/X sky130_fd_sc_hd__clkbuf_1
X_3533_ _3529_/X _3531_/X _3532_/X _3889_/Q _3577_/A VGND VGND VPWR VPWR _3889_/D
+ sky130_fd_sc_hd__a32o_1
X_3464_ _3877_/Q _3874_/Q _3552_/S VGND VGND VPWR VPWR _3465_/B sky130_fd_sc_hd__mux2_1
X_2415_ _3113_/A _2842_/C VGND VGND VPWR VPWR _2415_/Y sky130_fd_sc_hd__nor2_1
X_3395_ _3665_/Q _3391_/Y _3394_/Y VGND VGND VPWR VPWR _3395_/X sky130_fd_sc_hd__a21o_1
XFILLER_69_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2346_ _2346_/A VGND VGND VPWR VPWR _2346_/Y sky130_fd_sc_hd__inv_2
XFILLER_29_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2277_ _3196_/A _3053_/B VGND VGND VPWR VPWR _2453_/A sky130_fd_sc_hd__nor2_1
XFILLER_16_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2200_ _2199_/X _3631_/Q _2244_/S VGND VGND VPWR VPWR _3631_/D sky130_fd_sc_hd__mux2_1
XTAP_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3180_ _3188_/B _2292_/A _3009_/S VGND VGND VPWR VPWR _3180_/X sky130_fd_sc_hd__o21a_1
XFILLER_66_335 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2131_ _2850_/B _3032_/C _3056_/A VGND VGND VPWR VPWR _2132_/C sky130_fd_sc_hd__and3_1
X_2062_ _2062_/A _2062_/B _2062_/C VGND VGND VPWR VPWR _2063_/B sky130_fd_sc_hd__nand3_1
XFILLER_22_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2964_ _3002_/A _3725_/Q VGND VGND VPWR VPWR _2964_/Y sky130_fd_sc_hd__nand2_1
X_1915_ _1915_/A _1915_/B VGND VGND VPWR VPWR _1915_/X sky130_fd_sc_hd__and2_1
X_2895_ _3176_/B _2895_/B VGND VGND VPWR VPWR _2897_/A sky130_fd_sc_hd__nor2_1
XFILLER_8_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1846_ _1847_/A _3822_/Q VGND VGND VPWR VPWR _1846_/X sky130_fd_sc_hd__and2_1
X_3516_ _3559_/A _3516_/B VGND VGND VPWR VPWR _3516_/Y sky130_fd_sc_hd__nor2_1
Xclkbuf_leaf_21_i_clk clkbuf_2_3__f_i_clk/X VGND VGND VPWR VPWR _3733_/CLK sky130_fd_sc_hd__clkbuf_16
X_3447_ _3568_/A _3447_/B VGND VGND VPWR VPWR _3447_/X sky130_fd_sc_hd__or2_1
XFILLER_69_140 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3378_ _3372_/X _3375_/Y _3376_/Y _3377_/Y _3322_/A VGND VGND VPWR VPWR _3381_/A
+ sky130_fd_sc_hd__a41o_1
X_2329_ _3830_/Q _2329_/B VGND VGND VPWR VPWR _2330_/A sky130_fd_sc_hd__nor2_1
XFILLER_57_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_36_i_clk _3628_/CLK VGND VGND VPWR VPWR _3903_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_13_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_346 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_232 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2680_ _2863_/A input7/X _3121_/A VGND VGND VPWR VPWR _2680_/X sky130_fd_sc_hd__and3_1
X_3301_ _3585_/A VGND VGND VPWR VPWR _3589_/B sky130_fd_sc_hd__clkinv_2
XTAP_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3232_ _3244_/A _3831_/Q _3244_/C VGND VGND VPWR VPWR _3232_/X sky130_fd_sc_hd__and3_1
XTAP_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3163_ input40/X _3773_/Q _3165_/S VGND VGND VPWR VPWR _3773_/D sky130_fd_sc_hd__mux2_1
X_2114_ _2114_/A _2122_/A VGND VGND VPWR VPWR _2681_/B sky130_fd_sc_hd__and2_2
XFILLER_66_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3094_ _3094_/A _3747_/Q VGND VGND VPWR VPWR _3095_/B sky130_fd_sc_hd__nand2_1
XFILLER_39_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_316 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2045_ _2723_/A _2045_/B VGND VGND VPWR VPWR _2046_/B sky130_fd_sc_hd__nand2_1
XFILLER_22_213 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2947_ _2947_/A _3022_/B VGND VGND VPWR VPWR _3723_/D sky130_fd_sc_hd__nand2_1
X_2878_ _3701_/Q _2880_/A VGND VGND VPWR VPWR _2881_/B sky130_fd_sc_hd__or2_1
X_1829_ _3828_/Q VGND VGND VPWR VPWR _3379_/A sky130_fd_sc_hd__inv_2
XTAP_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_56 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3850_ _3852_/CLK _3850_/D VGND VGND VPWR VPWR _3850_/Q sky130_fd_sc_hd__dfxtp_1
X_3781_ _3837_/CLK _3781_/D VGND VGND VPWR VPWR _3781_/Q sky130_fd_sc_hd__dfxtp_1
X_2801_ _2800_/Y _2785_/B _2953_/A VGND VGND VPWR VPWR _2801_/X sky130_fd_sc_hd__a21o_1
XFILLER_74_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2732_ _3122_/B _3122_/A _2720_/X _2721_/Y _2731_/X VGND VGND VPWR VPWR _2732_/X
+ sky130_fd_sc_hd__a311o_1
X_2663_ _3756_/Q _2895_/B _3712_/Q _3057_/B VGND VGND VPWR VPWR _2663_/X sky130_fd_sc_hd__o22a_1
X_2594_ _3121_/A input9/X VGND VGND VPWR VPWR _2701_/A sky130_fd_sc_hd__nand2_1
XFILLER_5_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3215_ _3214_/X _3790_/Q _3263_/S VGND VGND VPWR VPWR _3790_/D sky130_fd_sc_hd__mux2_1
XFILLER_82_400 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3146_ input53/X _3756_/Q _3165_/S VGND VGND VPWR VPWR _3756_/D sky130_fd_sc_hd__mux2_1
X_3077_ _3829_/Q _3695_/Q _3077_/C _3565_/B VGND VGND VPWR VPWR _3077_/X sky130_fd_sc_hd__or4_1
XFILLER_82_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2028_ _2101_/C _2083_/A _2083_/B VGND VGND VPWR VPWR _2029_/B sky130_fd_sc_hd__nand3_1
XFILLER_24_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_135 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_308 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3000_ _2066_/Y _2960_/X _2999_/Y VGND VGND VPWR VPWR _3740_/D sky130_fd_sc_hd__o21ai_1
Xinput7 i_wb_addr[11] VGND VGND VPWR VPWR input7/X sky130_fd_sc_hd__clkbuf_2
XFILLER_49_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3902_ _3903_/CLK _3902_/D VGND VGND VPWR VPWR _3902_/Q sky130_fd_sc_hd__dfxtp_1
X_3833_ _3837_/CLK _3833_/D VGND VGND VPWR VPWR _3833_/Q sky130_fd_sc_hd__dfxtp_1
X_3764_ _3766_/CLK _3764_/D VGND VGND VPWR VPWR _3764_/Q sky130_fd_sc_hd__dfxtp_1
X_3695_ _3896_/CLK _3695_/D VGND VGND VPWR VPWR _3695_/Q sky130_fd_sc_hd__dfxtp_1
X_2715_ _2880_/A _3011_/A _3046_/B _2710_/X _2714_/X VGND VGND VPWR VPWR _2715_/X
+ sky130_fd_sc_hd__o2111a_1
X_2646_ _2876_/S _3769_/Q VGND VGND VPWR VPWR _2646_/Y sky130_fd_sc_hd__nand2_1
X_2577_ _2863_/A _2577_/B _3121_/A VGND VGND VPWR VPWR _2577_/X sky130_fd_sc_hd__and3_1
XFILLER_55_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3129_ _3099_/B _2856_/A _3138_/B _3128_/X _3115_/Y VGND VGND VPWR VPWR _3130_/A
+ sky130_fd_sc_hd__a221o_1
XFILLER_42_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_241 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_138 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3480_ _3559_/A _3480_/B VGND VGND VPWR VPWR _3480_/Y sky130_fd_sc_hd__nor2_1
X_2500_ _3757_/Q _2782_/A _2480_/Y _3727_/Q _2856_/B VGND VGND VPWR VPWR _2500_/X
+ sky130_fd_sc_hd__a221o_1
X_2431_ _3044_/B _3060_/B VGND VGND VPWR VPWR _2817_/B sky130_fd_sc_hd__nand2_1
XFILLER_37_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2362_ _3784_/Q _2362_/B VGND VGND VPWR VPWR _3188_/B sky130_fd_sc_hd__nand2_2
X_2293_ _2293_/A _2949_/A VGND VGND VPWR VPWR _2381_/B sky130_fd_sc_hd__nand2_1
XFILLER_37_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3816_ _3862_/CLK _3816_/D VGND VGND VPWR VPWR _3816_/Q sky130_fd_sc_hd__dfxtp_1
X_3747_ _3748_/CLK _3747_/D VGND VGND VPWR VPWR _3747_/Q sky130_fd_sc_hd__dfxtp_2
X_3678_ _3727_/CLK _3678_/D VGND VGND VPWR VPWR _3678_/Q sky130_fd_sc_hd__dfxtp_1
X_2629_ _2628_/Y _3682_/Q _2793_/A VGND VGND VPWR VPWR _3682_/D sky130_fd_sc_hd__mux2_1
XFILLER_28_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_355 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2980_ _3002_/A _3733_/Q VGND VGND VPWR VPWR _2980_/Y sky130_fd_sc_hd__nand2_1
XFILLER_61_255 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1931_ _2856_/A _2443_/A VGND VGND VPWR VPWR _1932_/A sky130_fd_sc_hd__nand2_1
XFILLER_42_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1862_ _3748_/Q _3747_/Q VGND VGND VPWR VPWR _2122_/A sky130_fd_sc_hd__nor2_1
X_3601_ _3601_/A _3606_/B VGND VGND VPWR VPWR _3601_/Y sky130_fd_sc_hd__nor2_1
Xinput21 i_wb_addr[6] VGND VGND VPWR VPWR _1955_/A sky130_fd_sc_hd__clkbuf_1
Xinput10 i_wb_addr[14] VGND VGND VPWR VPWR _2993_/A sky130_fd_sc_hd__clkbuf_2
Xinput54 i_wb_data[5] VGND VGND VPWR VPWR input54/X sky130_fd_sc_hd__clkbuf_1
Xinput32 i_wb_data[14] VGND VGND VPWR VPWR input32/X sky130_fd_sc_hd__clkbuf_1
Xinput43 i_wb_data[24] VGND VGND VPWR VPWR input43/X sky130_fd_sc_hd__clkbuf_1
X_3532_ _3689_/Q _3606_/B _3390_/Y VGND VGND VPWR VPWR _3532_/X sky130_fd_sc_hd__o21a_1
X_3463_ _3556_/A _3674_/Q _3462_/X _3406_/Y VGND VGND VPWR VPWR _3463_/X sky130_fd_sc_hd__a211o_1
X_2414_ _3032_/C _3056_/A VGND VGND VPWR VPWR _3113_/A sky130_fd_sc_hd__nand2_1
XFILLER_69_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3394_ _3394_/A _3402_/B VGND VGND VPWR VPWR _3394_/Y sky130_fd_sc_hd__nand2_1
X_2345_ _2179_/X _3122_/B _2338_/Y _2344_/Y VGND VGND VPWR VPWR _2346_/A sky130_fd_sc_hd__a31o_1
XFILLER_69_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2276_ _3009_/S VGND VGND VPWR VPWR _3053_/B sky130_fd_sc_hd__inv_2
XFILLER_25_425 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_200 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_23 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_230 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_66 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2130_ _2130_/A _2185_/A VGND VGND VPWR VPWR _3056_/A sky130_fd_sc_hd__nand2_2
XFILLER_66_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2061_ _2023_/B _2027_/A _2103_/C VGND VGND VPWR VPWR _2062_/C sky130_fd_sc_hd__o21bai_1
XFILLER_19_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2963_ _2168_/B _2960_/X _2962_/Y VGND VGND VPWR VPWR _3724_/D sky130_fd_sc_hd__o21ai_1
X_1914_ _2729_/A _3119_/A _2160_/B VGND VGND VPWR VPWR _1915_/B sky130_fd_sc_hd__a21oi_1
XFILLER_30_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2894_ _3752_/Q _3830_/Q _3623_/A VGND VGND VPWR VPWR _2894_/X sky130_fd_sc_hd__mux2_1
X_1845_ _1847_/A _3821_/Q VGND VGND VPWR VPWR _1845_/X sky130_fd_sc_hd__and2_1
X_3515_ _3511_/X _3513_/X _3514_/Y _3886_/Q _3577_/A VGND VGND VPWR VPWR _3886_/D
+ sky130_fd_sc_hd__a32o_1
X_3446_ _3874_/Q _3871_/Q _3552_/S VGND VGND VPWR VPWR _3447_/B sky130_fd_sc_hd__mux2_1
XFILLER_69_152 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3377_ _3899_/Q _3901_/Q VGND VGND VPWR VPWR _3377_/Y sky130_fd_sc_hd__nor2_1
X_2328_ _2328_/A _2328_/B VGND VGND VPWR VPWR _2328_/Y sky130_fd_sc_hd__nand2_1
XFILLER_57_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2259_ _2259_/A _2259_/B VGND VGND VPWR VPWR _2376_/C sky130_fd_sc_hd__nand2_2
XFILLER_25_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_199 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3300_ _3290_/Y _3306_/B _3298_/Y _3299_/Y VGND VGND VPWR VPWR _3820_/D sky130_fd_sc_hd__o31ai_1
XTAP_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3231_ _3797_/Q _3263_/S _3230_/X VGND VGND VPWR VPWR _3797_/D sky130_fd_sc_hd__a21o_1
XTAP_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3162_ input39/X _3772_/Q _3165_/S VGND VGND VPWR VPWR _3772_/D sky130_fd_sc_hd__mux2_1
X_2113_ _2113_/A _2185_/A VGND VGND VPWR VPWR _3057_/B sky130_fd_sc_hd__nand2_8
XFILLER_66_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3093_ _3032_/C _3088_/Y _3092_/X VGND VGND VPWR VPWR _3093_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_54_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2044_ _2044_/A VGND VGND VPWR VPWR _2045_/B sky130_fd_sc_hd__inv_2
XFILLER_47_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2946_ _3190_/B _2355_/B _3723_/Q VGND VGND VPWR VPWR _2947_/A sky130_fd_sc_hd__o21ai_1
XFILLER_30_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2877_ _3739_/Q _2879_/A VGND VGND VPWR VPWR _2881_/A sky130_fd_sc_hd__or2_1
X_1828_ _1828_/A VGND VGND VPWR VPWR _1828_/Y sky130_fd_sc_hd__inv_2
XFILLER_1_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3429_ _3568_/A _3429_/B VGND VGND VPWR VPWR _3429_/X sky130_fd_sc_hd__or2_1
XTAP_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_394 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_20_i_clk clkbuf_2_3__f_i_clk/X VGND VGND VPWR VPWR _3737_/CLK sky130_fd_sc_hd__clkbuf_16
X_2800_ _2800_/A _3032_/C VGND VGND VPWR VPWR _2800_/Y sky130_fd_sc_hd__nand2_1
X_3780_ _3830_/CLK _3780_/D VGND VGND VPWR VPWR _3780_/Q sky130_fd_sc_hd__dfxtp_1
X_2731_ _3739_/Q _2856_/B _2953_/A _2725_/X _2730_/X VGND VGND VPWR VPWR _2731_/X
+ sky130_fd_sc_hd__a2111o_1
Xclkbuf_leaf_35_i_clk _3628_/CLK VGND VGND VPWR VPWR _3900_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_8_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2662_ _2842_/C _2889_/A _2856_/A VGND VGND VPWR VPWR _2662_/Y sky130_fd_sc_hd__a21oi_1
XFILLER_67_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_40 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2593_ _3737_/Q _2480_/Y _2590_/X _2591_/X _2592_/X VGND VGND VPWR VPWR _2596_/A
+ sky130_fd_sc_hd__a2111oi_1
X_3214_ _3847_/Q _3270_/A _3229_/A _3704_/Q VGND VGND VPWR VPWR _3214_/X sky130_fd_sc_hd__a22o_1
X_3145_ input52/X _3755_/Q _3165_/S VGND VGND VPWR VPWR _3755_/D sky130_fd_sc_hd__mux2_1
XFILLER_39_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3076_ _3204_/C _3076_/B VGND VGND VPWR VPWR _3186_/C sky130_fd_sc_hd__nand2_1
XFILLER_82_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2027_ _2027_/A _2027_/B VGND VGND VPWR VPWR _2029_/A sky130_fd_sc_hd__nand2_1
XFILLER_35_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2929_ _2929_/A _2929_/B VGND VGND VPWR VPWR _2931_/B sky130_fd_sc_hd__nor2_1
XFILLER_2_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_464 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_243 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput8 i_wb_addr[12] VGND VGND VPWR VPWR input8/X sky130_fd_sc_hd__buf_2
XFILLER_24_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3901_ _3901_/CLK _3901_/D VGND VGND VPWR VPWR _3901_/Q sky130_fd_sc_hd__dfxtp_1
X_3832_ _3837_/CLK _3832_/D VGND VGND VPWR VPWR _3832_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_32_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_386 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3763_ _3766_/CLK _3763_/D VGND VGND VPWR VPWR _3763_/Q sky130_fd_sc_hd__dfxtp_1
X_3694_ _3887_/CLK _3694_/D VGND VGND VPWR VPWR _3694_/Q sky130_fd_sc_hd__dfxtp_1
X_2714_ _2711_/Y _2713_/X _2832_/B VGND VGND VPWR VPWR _2714_/X sky130_fd_sc_hd__o21a_1
XFILLER_10_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2645_ _3741_/Q VGND VGND VPWR VPWR _2885_/A sky130_fd_sc_hd__inv_2
XFILLER_10_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2576_ _2574_/Y _2575_/X _3122_/B VGND VGND VPWR VPWR _2576_/X sky130_fd_sc_hd__o21a_1
XFILLER_67_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3128_ _3128_/A _3128_/B _3024_/A VGND VGND VPWR VPWR _3128_/X sky130_fd_sc_hd__or3b_1
XFILLER_82_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3059_ _1835_/B _3618_/A _2321_/Y VGND VGND VPWR VPWR _3059_/Y sky130_fd_sc_hd__a21oi_1
XFILLER_42_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_103 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2430_ _3105_/B _2430_/B VGND VGND VPWR VPWR _2815_/B sky130_fd_sc_hd__nand2_1
XFILLER_51_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2361_ _2361_/A VGND VGND VPWR VPWR _3661_/D sky130_fd_sc_hd__clkinv_2
X_2292_ _2292_/A _3009_/S VGND VGND VPWR VPWR _2301_/A sky130_fd_sc_hd__nand2_1
XFILLER_49_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3815_ _3862_/CLK _3815_/D VGND VGND VPWR VPWR _3815_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_32_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3746_ _3865_/CLK _3746_/D VGND VGND VPWR VPWR _3746_/Q sky130_fd_sc_hd__dfxtp_1
X_3677_ _3727_/CLK _3677_/D VGND VGND VPWR VPWR _3677_/Q sky130_fd_sc_hd__dfxtp_1
X_2628_ _2623_/Y _3049_/B _2625_/X _2627_/X VGND VGND VPWR VPWR _2628_/Y sky130_fd_sc_hd__a31oi_1
X_2559_ _2803_/S VGND VGND VPWR VPWR _2559_/Y sky130_fd_sc_hd__inv_2
XFILLER_28_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_172 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_367 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_231 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_404 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1930_ _3829_/Q _3067_/A VGND VGND VPWR VPWR _2443_/A sky130_fd_sc_hd__nor2_1
X_1861_ _2854_/B VGND VGND VPWR VPWR _3026_/A sky130_fd_sc_hd__clkinv_2
X_3600_ _3595_/A _3589_/B _3580_/Y VGND VGND VPWR VPWR _3600_/X sky130_fd_sc_hd__a21o_1
Xinput22 i_wb_addr[7] VGND VGND VPWR VPWR _2624_/A sky130_fd_sc_hd__clkbuf_2
Xinput11 i_wb_addr[15] VGND VGND VPWR VPWR _2996_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_52_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3531_ _3568_/A _3531_/B VGND VGND VPWR VPWR _3531_/X sky130_fd_sc_hd__or2_1
Xinput55 i_wb_data[6] VGND VGND VPWR VPWR input55/X sky130_fd_sc_hd__clkbuf_1
Xinput33 i_wb_data[15] VGND VGND VPWR VPWR input33/X sky130_fd_sc_hd__clkbuf_1
Xinput44 i_wb_data[25] VGND VGND VPWR VPWR input44/X sky130_fd_sc_hd__clkbuf_1
XFILLER_6_382 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3462_ _3555_/A _3677_/Q VGND VGND VPWR VPWR _3462_/X sky130_fd_sc_hd__and2_1
X_3393_ _3553_/A _3579_/B VGND VGND VPWR VPWR _3402_/B sky130_fd_sc_hd__nor2_2
X_2413_ _2896_/A _2713_/A VGND VGND VPWR VPWR _3113_/C sky130_fd_sc_hd__nand2_1
X_2344_ _2344_/A _2798_/B VGND VGND VPWR VPWR _2344_/Y sky130_fd_sc_hd__nor2_1
XFILLER_69_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2275_ _2856_/B _2755_/C VGND VGND VPWR VPWR _3016_/A sky130_fd_sc_hd__nor2_1
XFILLER_37_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_212 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3729_ _3737_/CLK _3729_/D VGND VGND VPWR VPWR _3729_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_57_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_286 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2060_ _2060_/A _2577_/B VGND VGND VPWR VPWR _2062_/B sky130_fd_sc_hd__nand2_1
XFILLER_47_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2962_ _3002_/A _3724_/Q VGND VGND VPWR VPWR _2962_/Y sky130_fd_sc_hd__nand2_1
X_1913_ _3700_/Q _3745_/Q _3099_/B VGND VGND VPWR VPWR _2160_/B sky130_fd_sc_hd__a21oi_1
XFILLER_30_451 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2893_ _3707_/Q _2892_/X _2752_/B VGND VGND VPWR VPWR _3707_/D sky130_fd_sc_hd__o21a_1
X_1844_ _3746_/Q _1844_/B VGND VGND VPWR VPWR _1844_/Y sky130_fd_sc_hd__nor2_1
X_3514_ _3516_/B _3553_/A _3411_/A VGND VGND VPWR VPWR _3514_/Y sky130_fd_sc_hd__a21oi_1
X_3445_ _3556_/A _3671_/Q _3444_/Y _3406_/Y VGND VGND VPWR VPWR _3445_/X sky130_fd_sc_hd__a211o_1
X_3376_ _3900_/Q VGND VGND VPWR VPWR _3376_/Y sky130_fd_sc_hd__inv_2
XFILLER_69_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2327_ _3094_/A _2713_/A _2321_/Y _2326_/X VGND VGND VPWR VPWR _2327_/X sky130_fd_sc_hd__o22a_1
X_2258_ _2258_/A VGND VGND VPWR VPWR _2259_/A sky130_fd_sc_hd__inv_2
XFILLER_57_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2189_ _3174_/A _2183_/B _3628_/Q VGND VGND VPWR VPWR _2190_/B sky130_fd_sc_hd__o21a_1
XFILLER_13_418 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_145 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3230_ _3244_/A _3830_/Q _3244_/C VGND VGND VPWR VPWR _3230_/X sky130_fd_sc_hd__and3_1
XTAP_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3161_ input37/X _3771_/Q _3165_/S VGND VGND VPWR VPWR _3771_/D sky130_fd_sc_hd__mux2_1
XFILLER_12_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_359 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2112_ _3054_/A _2108_/Y _3023_/A VGND VGND VPWR VPWR _2112_/Y sky130_fd_sc_hd__o21ai_1
X_3092_ _3067_/B _2842_/C _3113_/A _3091_/X VGND VGND VPWR VPWR _3092_/X sky130_fd_sc_hd__a211o_1
X_2043_ _2749_/A VGND VGND VPWR VPWR _2723_/A sky130_fd_sc_hd__inv_2
XFILLER_47_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_351 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2945_ _3722_/Q _3190_/B _2941_/A _2944_/Y VGND VGND VPWR VPWR _3722_/D sky130_fd_sc_hd__a211o_1
XFILLER_13_18 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2876_ _3706_/Q _3771_/Q _2876_/S VGND VGND VPWR VPWR _3706_/D sky130_fd_sc_hd__mux2_1
X_1827_ _1827_/A _3828_/Q VGND VGND VPWR VPWR _1828_/A sky130_fd_sc_hd__nand2_1
X_3428_ _3871_/Q _3868_/Q _3552_/S VGND VGND VPWR VPWR _3429_/B sky130_fd_sc_hd__mux2_1
X_3359_ _3858_/Q _2251_/X _3363_/S VGND VGND VPWR VPWR _3858_/D sky130_fd_sc_hd__mux2_1
XTAP_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_2_1__f_i_clk clkbuf_0_i_clk/X VGND VGND VPWR VPWR clkbuf_leaf_9_i_clk/A sky130_fd_sc_hd__clkbuf_16
XFILLER_80_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_1_i_clk _3628_/CLK VGND VGND VPWR VPWR _3767_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_70_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_259 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2730_ _2727_/X _3088_/A _2856_/A VGND VGND VPWR VPWR _2730_/X sky130_fd_sc_hd__mux2_1
X_2661_ _3742_/Q VGND VGND VPWR VPWR _2889_/A sky130_fd_sc_hd__inv_2
XFILLER_5_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2592_ _2608_/A _3680_/Q _2839_/A _3729_/Q _2856_/B VGND VGND VPWR VPWR _2592_/X
+ sky130_fd_sc_hd__a32o_1
XFILLER_5_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3213_ _3212_/X _3789_/Q _3263_/S VGND VGND VPWR VPWR _3789_/D sky130_fd_sc_hd__mux2_1
XFILLER_39_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3144_ input49/X _3754_/Q _3165_/S VGND VGND VPWR VPWR _3754_/D sky130_fd_sc_hd__mux2_1
X_3075_ _3571_/A _3067_/B _3011_/A VGND VGND VPWR VPWR _3075_/Y sky130_fd_sc_hd__a21oi_1
XFILLER_82_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2026_ _2101_/C VGND VGND VPWR VPWR _2027_/B sky130_fd_sc_hd__inv_2
XFILLER_62_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_207 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2928_ _3716_/Q _2926_/B _2927_/X VGND VGND VPWR VPWR _3716_/D sky130_fd_sc_hd__a21o_1
X_2859_ _3699_/Q _2849_/Y _2859_/S VGND VGND VPWR VPWR _3699_/D sky130_fd_sc_hd__mux2_1
XFILLER_49_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_218 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput9 i_wb_addr[13] VGND VGND VPWR VPWR input9/X sky130_fd_sc_hd__clkbuf_2
XFILLER_36_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3900_ _3900_/CLK _3900_/D VGND VGND VPWR VPWR _3900_/Q sky130_fd_sc_hd__dfxtp_1
X_3831_ _3837_/CLK _3831_/D VGND VGND VPWR VPWR _3831_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_32_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3762_ _3766_/CLK _3762_/D VGND VGND VPWR VPWR _3762_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_32_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3693_ _3725_/CLK _3693_/D VGND VGND VPWR VPWR _3693_/Q sky130_fd_sc_hd__dfxtp_2
X_2713_ _2713_/A _3032_/C _2713_/C VGND VGND VPWR VPWR _2713_/X sky130_fd_sc_hd__and3_1
X_2644_ _3684_/Q VGND VGND VPWR VPWR _3504_/B sky130_fd_sc_hd__inv_2
X_2575_ _2839_/A _2762_/B _3679_/Q VGND VGND VPWR VPWR _2575_/X sky130_fd_sc_hd__and3_1
XFILLER_67_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3127_ _3127_/A _3190_/B _3127_/C VGND VGND VPWR VPWR _3127_/X sky130_fd_sc_hd__and3_1
XFILLER_27_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3058_ _3067_/B _3058_/B VGND VGND VPWR VPWR _3058_/Y sky130_fd_sc_hd__nor2_1
XFILLER_70_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2009_ _2009_/A _2009_/B VGND VGND VPWR VPWR _2013_/A sky130_fd_sc_hd__nor2_1
XFILLER_23_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_34_i_clk clkbuf_2_2__f_i_clk/X VGND VGND VPWR VPWR _3785_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_46_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2360_ _2315_/X _2337_/Y _3022_/B _2346_/Y _2359_/Y VGND VGND VPWR VPWR _2361_/A
+ sky130_fd_sc_hd__o2111ai_1
X_2291_ _2856_/A _2755_/C VGND VGND VPWR VPWR _2292_/A sky130_fd_sc_hd__nor2_1
XFILLER_37_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3814_ _3852_/CLK _3814_/D VGND VGND VPWR VPWR _3814_/Q sky130_fd_sc_hd__dfxtp_1
X_3745_ _3784_/CLK _3745_/D VGND VGND VPWR VPWR _3745_/Q sky130_fd_sc_hd__dfxtp_2
X_3676_ _3727_/CLK _3676_/D VGND VGND VPWR VPWR _3676_/Q sky130_fd_sc_hd__dfxtp_1
X_2627_ _3492_/B _2720_/B _2796_/B _2721_/A _3122_/B VGND VGND VPWR VPWR _2627_/X
+ sky130_fd_sc_hd__o311a_1
X_2558_ _3678_/Q VGND VGND VPWR VPWR _3468_/B sky130_fd_sc_hd__inv_2
X_2489_ _2488_/X _3668_/Q _2793_/A VGND VGND VPWR VPWR _3668_/D sky130_fd_sc_hd__mux2_1
XFILLER_28_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_184 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_379 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1860_ _2140_/A _2142_/B _2185_/A VGND VGND VPWR VPWR _2854_/B sky130_fd_sc_hd__and3_1
Xinput12 i_wb_addr[16] VGND VGND VPWR VPWR _2640_/B sky130_fd_sc_hd__dlymetal6s2s_1
Xinput45 i_wb_data[26] VGND VGND VPWR VPWR input45/X sky130_fd_sc_hd__clkbuf_1
X_3530_ _3888_/Q _3885_/Q _3607_/A VGND VGND VPWR VPWR _3531_/B sky130_fd_sc_hd__mux2_1
Xinput23 i_wb_addr[8] VGND VGND VPWR VPWR _2024_/A sky130_fd_sc_hd__dlymetal6s2s_1
Xinput34 i_wb_data[16] VGND VGND VPWR VPWR input34/X sky130_fd_sc_hd__clkbuf_1
Xinput56 i_wb_data[7] VGND VGND VPWR VPWR input56/X sky130_fd_sc_hd__clkbuf_1
X_3461_ _3457_/X _3459_/X _3460_/X _3877_/Q _3577_/A VGND VGND VPWR VPWR _3877_/D
+ sky130_fd_sc_hd__a32o_1
XFILLER_6_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3392_ _3552_/S _3585_/A _3897_/Q VGND VGND VPWR VPWR _3394_/A sky130_fd_sc_hd__or3b_1
XFILLER_42_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2412_ _2782_/A _3023_/A VGND VGND VPWR VPWR _2896_/A sky130_fd_sc_hd__nor2_1
XFILLER_69_313 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2343_ _3202_/A VGND VGND VPWR VPWR _2798_/B sky130_fd_sc_hd__inv_2
XFILLER_69_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2274_ _2330_/B _2832_/B VGND VGND VPWR VPWR _2755_/C sky130_fd_sc_hd__nand2_2
XFILLER_37_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_224 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1989_ _3743_/Q VGND VGND VPWR VPWR _2888_/A sky130_fd_sc_hd__clkinv_2
XFILLER_4_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3728_ _3737_/CLK _3728_/D VGND VGND VPWR VPWR _3728_/Q sky130_fd_sc_hd__dfxtp_2
X_3659_ _3860_/CLK _3659_/D VGND VGND VPWR VPWR _3659_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_28_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2961_ _3007_/A VGND VGND VPWR VPWR _3002_/A sky130_fd_sc_hd__buf_6
X_1912_ _2448_/A _2728_/B VGND VGND VPWR VPWR _3119_/A sky130_fd_sc_hd__nand2_2
XFILLER_30_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2892_ _2876_/S _2842_/C _2881_/X _2886_/X _2891_/X VGND VGND VPWR VPWR _2892_/X
+ sky130_fd_sc_hd__o2111a_1
XFILLER_8_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1843_ _3820_/Q VGND VGND VPWR VPWR _1844_/B sky130_fd_sc_hd__inv_2
X_3513_ _3568_/A _3513_/B VGND VGND VPWR VPWR _3513_/X sky130_fd_sc_hd__or2_1
X_3444_ _3559_/A _3444_/B VGND VGND VPWR VPWR _3444_/Y sky130_fd_sc_hd__nor2_1
X_3375_ _3607_/A _3611_/D _3583_/B VGND VGND VPWR VPWR _3375_/Y sky130_fd_sc_hd__o21ai_1
X_2326_ _3121_/B _2323_/Y _2376_/C _2397_/B VGND VGND VPWR VPWR _2326_/X sky130_fd_sc_hd__o31a_1
XFILLER_69_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2257_ _2329_/B _3122_/B VGND VGND VPWR VPWR _2257_/Y sky130_fd_sc_hd__nor2_1
XFILLER_57_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2188_ _3022_/B _3190_/B VGND VGND VPWR VPWR _2863_/B sky130_fd_sc_hd__nand2_1
XFILLER_43_16 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3160_ input36/X _3770_/Q _3165_/S VGND VGND VPWR VPWR _3770_/D sky130_fd_sc_hd__mux2_1
X_2111_ _2187_/B _2144_/B VGND VGND VPWR VPWR _3023_/A sky130_fd_sc_hd__nor2_4
XFILLER_39_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3091_ _2895_/B _3089_/X _3128_/B _2833_/A VGND VGND VPWR VPWR _3091_/X sky130_fd_sc_hd__o22a_1
XFILLER_58_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2042_ _2042_/A _2042_/B VGND VGND VPWR VPWR _2046_/A sky130_fd_sc_hd__nand2_1
XFILLER_62_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2944_ _2355_/B _2943_/X _3022_/A VGND VGND VPWR VPWR _2944_/Y sky130_fd_sc_hd__a21oi_1
XFILLER_30_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2875_ _2890_/A _2876_/S _2664_/Y VGND VGND VPWR VPWR _3705_/D sky130_fd_sc_hd__o21ai_1
X_1826_ _3611_/A VGND VGND VPWR VPWR _1827_/A sky130_fd_sc_hd__inv_2
X_3427_ _3556_/A _3668_/Q _3426_/Y _3406_/Y VGND VGND VPWR VPWR _3427_/X sky130_fd_sc_hd__a211o_1
XTAP_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3358_ _3857_/Q _2249_/X _3363_/S VGND VGND VPWR VPWR _3857_/D sky130_fd_sc_hd__mux2_1
XTAP_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2309_ _2746_/B VGND VGND VPWR VPWR _2796_/B sky130_fd_sc_hd__buf_8
XFILLER_57_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3289_ _3585_/A VGND VGND VPWR VPWR _3568_/A sky130_fd_sc_hd__buf_8
XFILLER_57_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_400 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_116 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_330 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_7 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2660_ _2608_/A _3685_/Q _2839_/A _3734_/Q _2856_/B VGND VGND VPWR VPWR _2660_/X
+ sky130_fd_sc_hd__a32o_1
XFILLER_60_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2591_ _2863_/A _2003_/A _3121_/A _3122_/B VGND VGND VPWR VPWR _2591_/X sky130_fd_sc_hd__a31o_1
X_3212_ _3846_/Q _3270_/A _3229_/A _3703_/Q VGND VGND VPWR VPWR _3212_/X sky130_fd_sc_hd__a22o_1
XFILLER_79_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3143_ input38/X _3753_/Q _3165_/S VGND VGND VPWR VPWR _3753_/D sky130_fd_sc_hd__mux2_1
X_3074_ _2329_/B _3601_/A _2953_/A VGND VGND VPWR VPWR _3074_/X sky130_fd_sc_hd__o21a_1
XFILLER_39_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2025_ _2025_/A _2025_/B VGND VGND VPWR VPWR _2101_/C sky130_fd_sc_hd__nand2_1
XFILLER_35_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2927_ _2941_/A _2929_/B VGND VGND VPWR VPWR _2927_/X sky130_fd_sc_hd__or2_1
X_2858_ _3618_/B _2851_/Y _3058_/B _2853_/Y _3619_/A VGND VGND VPWR VPWR _2859_/S
+ sky130_fd_sc_hd__o2111a_1
X_1809_ _3746_/Q VGND VGND VPWR VPWR _1847_/A sky130_fd_sc_hd__inv_2
X_2789_ _2810_/B _2775_/Y _2788_/Y VGND VGND VPWR VPWR _2790_/A sky130_fd_sc_hd__a21o_1
XFILLER_58_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_352 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_92 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3830_ _3830_/CLK _3830_/D VGND VGND VPWR VPWR _3830_/Q sky130_fd_sc_hd__dfxtp_2
X_3761_ _3766_/CLK _3761_/D VGND VGND VPWR VPWR _3761_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_32_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2712_ _2782_/A _3776_/Q VGND VGND VPWR VPWR _2713_/C sky130_fd_sc_hd__nand2_1
X_3692_ _3896_/CLK _3692_/D VGND VGND VPWR VPWR _3692_/Q sky130_fd_sc_hd__dfxtp_1
X_2643_ _3498_/B _2559_/Y _2642_/X VGND VGND VPWR VPWR _3683_/D sky130_fd_sc_hd__o21ai_1
X_2574_ _2574_/A VGND VGND VPWR VPWR _2574_/Y sky130_fd_sc_hd__inv_2
Xclkbuf_leaf_0_i_clk _3628_/CLK VGND VGND VPWR VPWR _3766_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_59_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_18 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3126_ _2171_/A _3106_/A _2436_/B _2435_/A _3049_/B VGND VGND VPWR VPWR _3127_/C
+ sky130_fd_sc_hd__a311o_1
XFILLER_55_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3057_ _3176_/B _3057_/B VGND VGND VPWR VPWR _3057_/Y sky130_fd_sc_hd__nor2_1
XFILLER_42_119 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2008_ _2080_/A _2101_/B VGND VGND VPWR VPWR _2009_/B sky130_fd_sc_hd__and2_1
XFILLER_50_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_38 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_285 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2290_ _3024_/B _2376_/C _3090_/B VGND VGND VPWR VPWR _3177_/A sky130_fd_sc_hd__and3_1
XFILLER_1_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_119 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3813_ _3852_/CLK _3813_/D VGND VGND VPWR VPWR _3813_/Q sky130_fd_sc_hd__dfxtp_1
X_3744_ _3774_/CLK _3744_/D VGND VGND VPWR VPWR _3744_/Q sky130_fd_sc_hd__dfxtp_4
X_3675_ _3882_/CLK _3675_/D VGND VGND VPWR VPWR _3675_/Q sky130_fd_sc_hd__dfxtp_1
Xoutput100 _3804_/Q VGND VGND VPWR VPWR o_wb_data[7] sky130_fd_sc_hd__clkbuf_1
X_2626_ _3121_/A _2996_/A VGND VGND VPWR VPWR _2721_/A sky130_fd_sc_hd__nand2_1
X_2557_ _2556_/X _3677_/Q _2793_/A VGND VGND VPWR VPWR _3677_/D sky130_fd_sc_hd__mux2_1
X_2488_ _3122_/B _2486_/X _2608_/A _2485_/Y _2487_/X VGND VGND VPWR VPWR _2488_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_46_16 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_211 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3109_ _3104_/X _3105_/Y _3108_/X VGND VGND VPWR VPWR _3109_/Y sky130_fd_sc_hd__a21oi_1
XFILLER_55_266 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_200 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput13 i_wb_addr[17] VGND VGND VPWR VPWR _3001_/A sky130_fd_sc_hd__buf_2
Xinput46 i_wb_data[27] VGND VGND VPWR VPWR input46/X sky130_fd_sc_hd__clkbuf_1
Xinput24 i_wb_addr[9] VGND VGND VPWR VPWR _2654_/A sky130_fd_sc_hd__clkbuf_2
Xinput35 i_wb_data[17] VGND VGND VPWR VPWR input35/X sky130_fd_sc_hd__clkbuf_1
Xinput57 i_wb_data[8] VGND VGND VPWR VPWR input57/X sky130_fd_sc_hd__clkbuf_1
X_3460_ _3677_/Q _3606_/B _3390_/Y VGND VGND VPWR VPWR _3460_/X sky130_fd_sc_hd__o21a_1
X_3391_ _3571_/A _3589_/B VGND VGND VPWR VPWR _3391_/Y sky130_fd_sc_hd__nor2_2
X_2411_ _2411_/A _2411_/B VGND VGND VPWR VPWR _2411_/Y sky130_fd_sc_hd__nor2_1
XFILLER_69_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2342_ _2777_/A _3049_/B VGND VGND VPWR VPWR _3202_/A sky130_fd_sc_hd__nor2_2
X_2273_ _3011_/A VGND VGND VPWR VPWR _2856_/B sky130_fd_sc_hd__clkinv_8
XFILLER_77_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3727_ _3727_/CLK _3727_/D VGND VGND VPWR VPWR _3727_/Q sky130_fd_sc_hd__dfxtp_1
X_1988_ _1988_/A VGND VGND VPWR VPWR _2012_/B sky130_fd_sc_hd__inv_2
Xclkbuf_leaf_33_i_clk clkbuf_2_2__f_i_clk/X VGND VGND VPWR VPWR _3887_/CLK sky130_fd_sc_hd__clkbuf_16
X_3658_ _3860_/CLK _3658_/D VGND VGND VPWR VPWR _3658_/Q sky130_fd_sc_hd__dfxtp_1
X_3589_ _3594_/A _3589_/B VGND VGND VPWR VPWR _3589_/Y sky130_fd_sc_hd__nand2_1
X_2609_ _3730_/Q _2856_/B _2608_/X VGND VGND VPWR VPWR _2609_/Y sky130_fd_sc_hd__a21oi_1
XFILLER_43_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2960_ _3007_/A VGND VGND VPWR VPWR _2960_/X sky130_fd_sc_hd__buf_6
X_1911_ _3725_/Q VGND VGND VPWR VPWR _2728_/B sky130_fd_sc_hd__inv_2
XFILLER_42_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2891_ _2891_/A _2891_/B _2891_/C _2891_/D VGND VGND VPWR VPWR _2891_/X sky130_fd_sc_hd__and4_1
X_1842_ _3746_/Q _1842_/B VGND VGND VPWR VPWR _1842_/Y sky130_fd_sc_hd__nor2_1
X_3512_ _3885_/Q _3882_/Q _3607_/A VGND VGND VPWR VPWR _3513_/B sky130_fd_sc_hd__mux2_1
X_3443_ _3439_/X _3441_/X _3442_/Y _3874_/Q _3577_/A VGND VGND VPWR VPWR _3874_/D
+ sky130_fd_sc_hd__a32o_1
X_3374_ _3615_/A _3902_/Q VGND VGND VPWR VPWR _3611_/D sky130_fd_sc_hd__nand2_1
X_2325_ _3128_/A VGND VGND VPWR VPWR _2397_/B sky130_fd_sc_hd__inv_2
X_2256_ _2255_/X _3659_/Q _3327_/B VGND VGND VPWR VPWR _3659_/D sky130_fd_sc_hd__mux2_1
XFILLER_72_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2187_ _2187_/A _2187_/B VGND VGND VPWR VPWR _3190_/B sky130_fd_sc_hd__nand2_8
XFILLER_43_28 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_353 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2110_ _3010_/B VGND VGND VPWR VPWR _2144_/B sky130_fd_sc_hd__inv_2
X_3090_ _3176_/B _3090_/B VGND VGND VPWR VPWR _3128_/B sky130_fd_sc_hd__nor2_1
X_2041_ _3727_/Q VGND VGND VPWR VPWR _2042_/B sky130_fd_sc_hd__inv_2
XFILLER_54_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2943_ _2943_/A _2943_/B VGND VGND VPWR VPWR _2943_/X sky130_fd_sc_hd__or2_1
X_2874_ _3705_/Q VGND VGND VPWR VPWR _2890_/A sky130_fd_sc_hd__inv_2
X_1825_ _3865_/Q _1825_/B VGND VGND VPWR VPWR _3611_/A sky130_fd_sc_hd__nor2_2
X_3426_ _3559_/A _3426_/B VGND VGND VPWR VPWR _3426_/Y sky130_fd_sc_hd__nor2_1
X_3357_ _3856_/Q _2247_/X _3363_/S VGND VGND VPWR VPWR _3856_/D sky130_fd_sc_hd__mux2_1
XTAP_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2308_ _3699_/Q _3700_/Q VGND VGND VPWR VPWR _2746_/B sky130_fd_sc_hd__nor2_4
XFILLER_57_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3288_ _3611_/A _3319_/A VGND VGND VPWR VPWR _3585_/A sky130_fd_sc_hd__nor2_8
XFILLER_57_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2239_ _3650_/Q _3647_/Q _3362_/S VGND VGND VPWR VPWR _2239_/X sky130_fd_sc_hd__mux2_1
XFILLER_72_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_16 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_128 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_150 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2590_ _3767_/Q _3058_/B _2589_/Y VGND VGND VPWR VPWR _2590_/X sky130_fd_sc_hd__o21a_1
X_3211_ _3210_/X _3788_/Q _3263_/S VGND VGND VPWR VPWR _3788_/D sky130_fd_sc_hd__mux2_1
X_3142_ input27/X _3752_/Q _3165_/S VGND VGND VPWR VPWR _3752_/D sky130_fd_sc_hd__mux2_1
XFILLER_39_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3073_ _2815_/Y _3073_/B _3073_/C VGND VGND VPWR VPWR _3081_/B sky130_fd_sc_hd__and3b_1
XFILLER_35_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2024_ _2024_/A _3732_/Q VGND VGND VPWR VPWR _2025_/B sky130_fd_sc_hd__nand2_1
XFILLER_35_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2926_ _3716_/Q _2926_/B VGND VGND VPWR VPWR _2929_/B sky130_fd_sc_hd__nor2_1
X_2857_ _2857_/A _2857_/B _2856_/Y VGND VGND VPWR VPWR _3619_/A sky130_fd_sc_hd__nor3b_1
XFILLER_40_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2788_ _3725_/Q _2788_/B VGND VGND VPWR VPWR _2788_/Y sky130_fd_sc_hd__nor2_1
X_3409_ _3568_/A _3409_/B VGND VGND VPWR VPWR _3409_/X sky130_fd_sc_hd__or2_1
XTAP_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3760_ _3766_/CLK _3760_/D VGND VGND VPWR VPWR _3760_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_71_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2711_ _2711_/A _3032_/C VGND VGND VPWR VPWR _2711_/Y sky130_fd_sc_hd__nor2_1
X_3691_ _3896_/CLK _3691_/D VGND VGND VPWR VPWR _3691_/Q sky130_fd_sc_hd__dfxtp_1
X_2642_ _2636_/X _2637_/X _2638_/X _2641_/X _2793_/A VGND VGND VPWR VPWR _2642_/X
+ sky130_fd_sc_hd__a41o_1
X_2573_ _3121_/A input8/X VGND VGND VPWR VPWR _2574_/A sky130_fd_sc_hd__nand2_1
XFILLER_82_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3125_ _1859_/B _3127_/A _3124_/X VGND VGND VPWR VPWR _3749_/D sky130_fd_sc_hd__o21ai_1
XFILLER_27_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3056_ _3056_/A _3056_/B VGND VGND VPWR VPWR _3056_/Y sky130_fd_sc_hd__nor2_1
XFILLER_82_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2007_ _2993_/A _3738_/Q VGND VGND VPWR VPWR _2101_/B sky130_fd_sc_hd__xnor2_1
XFILLER_35_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3889_ _3890_/CLK _3889_/D VGND VGND VPWR VPWR _3889_/Q sky130_fd_sc_hd__dfxtp_1
X_2909_ _2907_/X _2901_/Y _3022_/B _2908_/X VGND VGND VPWR VPWR _3710_/D sky130_fd_sc_hd__o211a_1
XFILLER_58_231 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3812_ _3852_/CLK _3812_/D VGND VGND VPWR VPWR _3812_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_20_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3743_ _3849_/CLK _3743_/D VGND VGND VPWR VPWR _3743_/Q sky130_fd_sc_hd__dfxtp_1
X_3674_ _3882_/CLK _3674_/D VGND VGND VPWR VPWR _3674_/Q sky130_fd_sc_hd__dfxtp_1
Xoutput101 _3805_/Q VGND VGND VPWR VPWR o_wb_data[8] sky130_fd_sc_hd__clkbuf_1
X_2625_ _2625_/A _2668_/B _2721_/B VGND VGND VPWR VPWR _2625_/X sky130_fd_sc_hd__or3_1
X_2556_ _2556_/A _2556_/B _2556_/C _2556_/D VGND VGND VPWR VPWR _2556_/X sky130_fd_sc_hd__or4_1
X_2487_ _3755_/Q _2782_/A _2480_/Y _3725_/Q VGND VGND VPWR VPWR _2487_/X sky130_fd_sc_hd__a22o_1
X_3108_ _2344_/A _2798_/Y _3107_/X VGND VGND VPWR VPWR _3108_/X sky130_fd_sc_hd__a21o_1
XFILLER_55_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3039_ _3039_/A _3039_/B VGND VGND VPWR VPWR _3042_/A sky130_fd_sc_hd__nand2_1
XFILLER_55_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput25 i_wb_ctrl_stb VGND VGND VPWR VPWR _2174_/A sky130_fd_sc_hd__buf_2
Xinput36 i_wb_data[18] VGND VGND VPWR VPWR input36/X sky130_fd_sc_hd__clkbuf_1
Xinput14 i_wb_addr[18] VGND VGND VPWR VPWR _3004_/A sky130_fd_sc_hd__clkbuf_2
Xinput47 i_wb_data[28] VGND VGND VPWR VPWR input47/X sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_6_341 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput58 i_wb_data[9] VGND VGND VPWR VPWR input58/X sky130_fd_sc_hd__clkbuf_1
XFILLER_6_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2410_ _2855_/D _2850_/B VGND VGND VPWR VPWR _2411_/B sky130_fd_sc_hd__or2b_1
X_3390_ _3579_/B VGND VGND VPWR VPWR _3390_/Y sky130_fd_sc_hd__clkinv_4
X_2341_ _3699_/Q _2341_/B VGND VGND VPWR VPWR _2344_/A sky130_fd_sc_hd__nor2_1
XFILLER_69_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2272_ _2376_/C _2260_/Y _3024_/B _3177_/B _3017_/B VGND VGND VPWR VPWR _2306_/A
+ sky130_fd_sc_hd__o2111ai_1
XFILLER_77_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1987_ _3740_/Q _3741_/Q VGND VGND VPWR VPWR _1988_/A sky130_fd_sc_hd__nand2_1
X_3726_ _3727_/CLK _3726_/D VGND VGND VPWR VPWR _3726_/Q sky130_fd_sc_hd__dfxtp_1
X_3657_ _3860_/CLK _3657_/D VGND VGND VPWR VPWR _3657_/Q sky130_fd_sc_hd__dfxtp_1
X_3588_ _3588_/A _3588_/B VGND VGND VPWR VPWR _3594_/A sky130_fd_sc_hd__nand2_1
X_2608_ _2608_/A _3681_/Q _2839_/A VGND VGND VPWR VPWR _2608_/X sky130_fd_sc_hd__and3_1
X_2539_ _2538_/X _3675_/Q _2793_/A VGND VGND VPWR VPWR _3675_/D sky130_fd_sc_hd__mux2_1
XFILLER_11_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1910_ _3724_/Q VGND VGND VPWR VPWR _2448_/A sky130_fd_sc_hd__inv_2
X_2890_ _2890_/A _3742_/Q VGND VGND VPWR VPWR _2891_/D sky130_fd_sc_hd__nand2_1
X_1841_ _3826_/Q VGND VGND VPWR VPWR _1842_/B sky130_fd_sc_hd__inv_2
XFILLER_8_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3511_ _3556_/A _3682_/Q _3510_/X _3406_/Y VGND VGND VPWR VPWR _3511_/X sky130_fd_sc_hd__a211o_1
X_3442_ _3444_/B _3553_/A _3411_/A VGND VGND VPWR VPWR _3442_/Y sky130_fd_sc_hd__a21oi_1
X_3373_ _3903_/Q VGND VGND VPWR VPWR _3615_/A sky130_fd_sc_hd__inv_2
X_2324_ _2752_/B _3024_/B VGND VGND VPWR VPWR _3128_/A sky130_fd_sc_hd__nand2_1
X_2255_ _3658_/Q _3655_/Q _3826_/Q VGND VGND VPWR VPWR _2255_/X sky130_fd_sc_hd__mux2_1
X_2186_ _2941_/A VGND VGND VPWR VPWR _3022_/B sky130_fd_sc_hd__inv_6
XFILLER_80_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3709_ _3774_/CLK _3709_/D VGND VGND VPWR VPWR _3709_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_0_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_436 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_465 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2040_ _2040_/A _2040_/B VGND VGND VPWR VPWR _2048_/A sky130_fd_sc_hd__nand2_1
Xclkbuf_leaf_32_i_clk clkbuf_2_2__f_i_clk/X VGND VGND VPWR VPWR _3896_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_62_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2942_ _2943_/B _2359_/A _2940_/Y _3721_/Q _2941_/A VGND VGND VPWR VPWR _3721_/D
+ sky130_fd_sc_hd__a221o_1
XFILLER_15_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2873_ _3704_/Q _2752_/B _2646_/Y VGND VGND VPWR VPWR _3704_/D sky130_fd_sc_hd__a21bo_1
X_1824_ _3327_/A _3864_/Q VGND VGND VPWR VPWR _1825_/B sky130_fd_sc_hd__nand2_1
X_3425_ _3421_/X _3423_/X _3424_/Y _3871_/Q _3577_/A VGND VGND VPWR VPWR _3871_/D
+ sky130_fd_sc_hd__a32o_1
X_3356_ _3855_/Q _2245_/X _3363_/S VGND VGND VPWR VPWR _3855_/D sky130_fd_sc_hd__mux2_1
XTAP_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3287_ _3379_/B VGND VGND VPWR VPWR _3319_/A sky130_fd_sc_hd__inv_2
XFILLER_38_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2307_ _3660_/Q _2257_/Y _2307_/S VGND VGND VPWR VPWR _3660_/D sky130_fd_sc_hd__mux2_1
X_2238_ _2237_/X _3650_/Q _2244_/S VGND VGND VPWR VPWR _3650_/D sky130_fd_sc_hd__mux2_1
XTAP_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2169_ input5/X _2169_/B VGND VGND VPWR VPWR _2170_/B sky130_fd_sc_hd__nor2_1
XFILLER_53_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_144 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3210_ _3845_/Q _3270_/A _3229_/A _3702_/Q VGND VGND VPWR VPWR _3210_/X sky130_fd_sc_hd__a22o_1
XFILLER_39_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3141_ _3140_/X _2185_/A _3141_/S VGND VGND VPWR VPWR _3751_/D sky130_fd_sc_hd__mux2_1
XFILLER_39_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3072_ _3072_/A _3072_/B VGND VGND VPWR VPWR _3073_/C sky130_fd_sc_hd__nor2_1
XFILLER_54_107 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2023_ _2638_/A _2023_/B VGND VGND VPWR VPWR _2025_/A sky130_fd_sc_hd__nand2_1
XFILLER_62_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2925_ _2926_/B _2924_/Y _2941_/A VGND VGND VPWR VPWR _3715_/D sky130_fd_sc_hd__a21oi_1
X_2856_ _2856_/A _2856_/B VGND VGND VPWR VPWR _2856_/Y sky130_fd_sc_hd__nor2_1
X_2787_ _2888_/A _3011_/A _2148_/A _2786_/X VGND VGND VPWR VPWR _2787_/X sky130_fd_sc_hd__o22a_1
XFILLER_49_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3408_ _3868_/Q _3897_/Q _3552_/S VGND VGND VPWR VPWR _3409_/B sky130_fd_sc_hd__mux2_1
XTAP_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3339_ _3838_/Q _2211_/X _3827_/D VGND VGND VPWR VPWR _3838_/D sky130_fd_sc_hd__mux2_1
XTAP_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_140 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_379 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2710_ _2810_/B _2709_/Y _2419_/Y VGND VGND VPWR VPWR _2710_/X sky130_fd_sc_hd__a21o_1
X_3690_ _3725_/CLK _3690_/D VGND VGND VPWR VPWR _3690_/Q sky130_fd_sc_hd__dfxtp_2
X_2641_ _2639_/X _2640_/Y _3049_/B VGND VGND VPWR VPWR _2641_/X sky130_fd_sc_hd__a21o_1
X_2572_ _3679_/Q VGND VGND VPWR VPWR _3474_/B sky130_fd_sc_hd__inv_2
XFILLER_58_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3124_ _3123_/X _3190_/B _3141_/S VGND VGND VPWR VPWR _3124_/X sky130_fd_sc_hd__a21o_1
XFILLER_82_235 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3055_ _2368_/A _2368_/B _2453_/B _3053_/X _3054_/X VGND VGND VPWR VPWR _3083_/A
+ sky130_fd_sc_hd__a2111o_1
X_2006_ _2006_/A _2006_/B VGND VGND VPWR VPWR _2080_/A sky130_fd_sc_hd__nor2_1
XFILLER_50_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2908_ _3710_/Q _2914_/B VGND VGND VPWR VPWR _2908_/X sky130_fd_sc_hd__or2_1
X_3888_ _3896_/CLK _3888_/D VGND VGND VPWR VPWR _3888_/Q sky130_fd_sc_hd__dfxtp_1
X_2839_ _2839_/A _3698_/Q VGND VGND VPWR VPWR _2839_/Y sky130_fd_sc_hd__nand2_1
XTAP_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3811_ _3852_/CLK _3811_/D VGND VGND VPWR VPWR _3811_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_20_316 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3742_ _3849_/CLK _3742_/D VGND VGND VPWR VPWR _3742_/Q sky130_fd_sc_hd__dfxtp_2
X_3673_ _3877_/CLK _3673_/D VGND VGND VPWR VPWR _3673_/Q sky130_fd_sc_hd__dfxtp_1
X_2624_ _2624_/A VGND VGND VPWR VPWR _2625_/A sky130_fd_sc_hd__inv_2
Xoutput102 _3806_/Q VGND VGND VPWR VPWR o_wb_data[9] sky130_fd_sc_hd__clkbuf_1
X_2555_ _2553_/X _2554_/X _2480_/Y _3734_/Q VGND VGND VPWR VPWR _2556_/D sky130_fd_sc_hd__a22o_1
X_2486_ _2540_/B _3121_/A _2485_/Y _2762_/B VGND VGND VPWR VPWR _2486_/X sky130_fd_sc_hd__a22o_1
X_3107_ input5/X _2429_/B _2175_/A _3106_/Y _2742_/B VGND VGND VPWR VPWR _3107_/X
+ sky130_fd_sc_hd__o221a_1
XFILLER_46_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3038_ _3038_/A _3038_/B VGND VGND VPWR VPWR _3039_/A sky130_fd_sc_hd__nand2_1
XFILLER_51_430 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_154 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_452 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_76 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput26 i_wb_cyc VGND VGND VPWR VPWR _2362_/B sky130_fd_sc_hd__clkbuf_4
Xinput37 i_wb_data[19] VGND VGND VPWR VPWR input37/X sky130_fd_sc_hd__clkbuf_1
Xinput15 i_wb_addr[19] VGND VGND VPWR VPWR _2676_/B sky130_fd_sc_hd__dlymetal6s2s_1
Xinput59 i_wb_data_stb VGND VGND VPWR VPWR _2435_/A sky130_fd_sc_hd__buf_4
Xinput48 i_wb_data[29] VGND VGND VPWR VPWR input48/X sky130_fd_sc_hd__clkbuf_1
XFILLER_6_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2340_ _2340_/A VGND VGND VPWR VPWR _2341_/B sky130_fd_sc_hd__inv_2
X_2271_ _3138_/C _2948_/B _2271_/C VGND VGND VPWR VPWR _3017_/B sky130_fd_sc_hd__and3_1
XFILLER_25_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1986_ _1986_/A _2006_/A _2006_/B VGND VGND VPWR VPWR _2069_/A sky130_fd_sc_hd__nor3_2
X_3725_ _3725_/CLK _3725_/D VGND VGND VPWR VPWR _3725_/Q sky130_fd_sc_hd__dfxtp_4
X_3656_ _3860_/CLK _3656_/D VGND VGND VPWR VPWR _3656_/Q sky130_fd_sc_hd__dfxtp_1
X_3587_ _3899_/Q VGND VGND VPWR VPWR _3588_/B sky130_fd_sc_hd__inv_2
X_2607_ _2880_/A _2600_/Y _2606_/Y VGND VGND VPWR VPWR _2607_/X sky130_fd_sc_hd__o21a_1
X_2538_ _2538_/A _2538_/B _2538_/C _2538_/D VGND VGND VPWR VPWR _2538_/X sky130_fd_sc_hd__or4_1
XFILLER_75_319 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2469_ _3753_/Q _2782_/A _2608_/A _2468_/C _2468_/X VGND VGND VPWR VPWR _2469_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_68_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_268 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1840_ _3825_/Q _3746_/Q VGND VGND VPWR VPWR _1840_/X sky130_fd_sc_hd__or2_1
XFILLER_30_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3510_ _3555_/A _3685_/Q VGND VGND VPWR VPWR _3510_/X sky130_fd_sc_hd__and2_1
X_3441_ _3568_/A _3441_/B VGND VGND VPWR VPWR _3441_/X sky130_fd_sc_hd__or2_1
X_3372_ _3581_/B _3607_/A _3583_/B VGND VGND VPWR VPWR _3372_/X sky130_fd_sc_hd__a21o_1
XFILLER_40_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2323_ _2367_/A _2369_/B VGND VGND VPWR VPWR _2323_/Y sky130_fd_sc_hd__nor2_1
X_2254_ _2253_/X _3658_/Q _3327_/B VGND VGND VPWR VPWR _3658_/D sky130_fd_sc_hd__mux2_1
XFILLER_69_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2185_ _2185_/A _2185_/B VGND VGND VPWR VPWR _2941_/A sky130_fd_sc_hd__nor2_8
XFILLER_65_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_411 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_260 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1969_ _3730_/Q _3731_/Q VGND VGND VPWR VPWR _1970_/B sky130_fd_sc_hd__nand2_1
X_3708_ _3774_/CLK _3708_/D VGND VGND VPWR VPWR _3708_/Q sky130_fd_sc_hd__dfxtp_1
X_3639_ _3706_/CLK _3639_/D VGND VGND VPWR VPWR _3639_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_0_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_448 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_341 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2941_ _2941_/A _2941_/B _2940_/Y VGND VGND VPWR VPWR _3720_/D sky130_fd_sc_hd__or3b_1
XFILLER_62_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2872_ _2884_/A _2876_/S _2631_/Y VGND VGND VPWR VPWR _3703_/D sky130_fd_sc_hd__o21ai_1
X_1823_ _3863_/Q VGND VGND VPWR VPWR _3327_/A sky130_fd_sc_hd__clkinv_2
X_3424_ _3426_/B _3553_/A _3411_/A VGND VGND VPWR VPWR _3424_/Y sky130_fd_sc_hd__a21oi_1
X_3355_ _3854_/Q _2243_/X _3363_/S VGND VGND VPWR VPWR _3854_/D sky130_fd_sc_hd__mux2_1
XTAP_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3286_ _3611_/C _3896_/Q VGND VGND VPWR VPWR _3286_/X sky130_fd_sc_hd__and2_1
X_2306_ _2306_/A _2306_/B VGND VGND VPWR VPWR _2307_/S sky130_fd_sc_hd__nor2_1
X_2237_ _3649_/Q _3646_/Q _3362_/S VGND VGND VPWR VPWR _2237_/X sky130_fd_sc_hd__mux2_1
XTAP_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2168_ _2540_/B _2168_/B VGND VGND VPWR VPWR _2779_/B sky130_fd_sc_hd__nor2_1
XFILLER_54_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2099_ _2099_/A _2099_/B VGND VGND VPWR VPWR _2368_/A sky130_fd_sc_hd__nor2_2
XFILLER_53_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_399 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_156 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_285 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3140_ _2755_/C _2711_/Y _3137_/Y _3138_/Y _3139_/X VGND VGND VPWR VPWR _3140_/X
+ sky130_fd_sc_hd__o41a_1
XFILLER_67_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3071_ _2460_/A _2433_/B _3199_/B _2341_/B _3202_/A VGND VGND VPWR VPWR _3072_/B
+ sky130_fd_sc_hd__a32o_1
X_2022_ _3732_/Q VGND VGND VPWR VPWR _2023_/B sky130_fd_sc_hd__inv_2
XFILLER_54_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2924_ _2924_/A _3715_/Q VGND VGND VPWR VPWR _2924_/Y sky130_fd_sc_hd__nand2_1
X_2855_ _3044_/B _2953_/A _3020_/A _2855_/D VGND VGND VPWR VPWR _2857_/B sky130_fd_sc_hd__or4_1
X_2786_ _2781_/Y _2782_/Y _2899_/A _2785_/Y VGND VGND VPWR VPWR _2786_/X sky130_fd_sc_hd__a211o_1
X_3407_ _3665_/Q _3556_/A _3405_/Y _3406_/Y VGND VGND VPWR VPWR _3407_/X sky130_fd_sc_hd__a211o_1
X_3338_ _3837_/Q _2209_/X _3827_/D VGND VGND VPWR VPWR _3837_/D sky130_fd_sc_hd__mux2_1
XTAP_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3269_ _3268_/X _3816_/Q _3366_/S VGND VGND VPWR VPWR _3816_/D sky130_fd_sc_hd__mux2_1
XFILLER_45_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_303 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_31_i_clk clkbuf_2_2__f_i_clk/X VGND VGND VPWR VPWR _3897_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_55_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_391 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2640_ _3121_/A _2640_/B VGND VGND VPWR VPWR _2640_/Y sky130_fd_sc_hd__nand2_1
X_2571_ _3468_/B _2559_/Y _2570_/X VGND VGND VPWR VPWR _3678_/D sky130_fd_sc_hd__o21ai_1
X_3123_ _3117_/Y _3118_/Y _3120_/X _3122_/X VGND VGND VPWR VPWR _3123_/X sky130_fd_sc_hd__a31o_1
XFILLER_82_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3054_ _3054_/A _3054_/B VGND VGND VPWR VPWR _3054_/X sky130_fd_sc_hd__or2_1
XFILLER_82_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2005_ _2005_/A _2005_/B VGND VGND VPWR VPWR _2009_/A sky130_fd_sc_hd__nand2_1
XFILLER_23_358 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2907_ _3754_/Q _3832_/Q _3623_/A VGND VGND VPWR VPWR _2907_/X sky130_fd_sc_hd__mux2_1
X_3887_ _3887_/CLK _3887_/D VGND VGND VPWR VPWR _3887_/Q sky130_fd_sc_hd__dfxtp_1
X_2838_ _3698_/Q VGND VGND VPWR VPWR _2838_/Y sky130_fd_sc_hd__inv_2
X_2769_ _2860_/B _3058_/B _2619_/A VGND VGND VPWR VPWR _2769_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_76_49 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_70 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3810_ _3846_/CLK _3810_/D VGND VGND VPWR VPWR _3810_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_32_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3741_ _3861_/CLK _3741_/D VGND VGND VPWR VPWR _3741_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_70_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3672_ _3882_/CLK _3672_/D VGND VGND VPWR VPWR _3672_/Q sky130_fd_sc_hd__dfxtp_1
X_2623_ _3731_/Q _2856_/B _2608_/A _2617_/Y _2622_/X VGND VGND VPWR VPWR _2623_/Y
+ sky130_fd_sc_hd__a221oi_1
Xoutput103 _3628_/Q VGND VGND VPWR VPWR o_wb_stall sky130_fd_sc_hd__clkbuf_1
X_2554_ _3764_/Q _3058_/B VGND VGND VPWR VPWR _2554_/X sky130_fd_sc_hd__or2_1
X_2485_ _3405_/B _2796_/B VGND VGND VPWR VPWR _2485_/Y sky130_fd_sc_hd__nor2_1
X_3106_ _3106_/A _3106_/B VGND VGND VPWR VPWR _3106_/Y sky130_fd_sc_hd__nor2_1
XFILLER_55_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3037_ _3036_/Y _2453_/A _2136_/Y VGND VGND VPWR VPWR _3038_/B sky130_fd_sc_hd__o21ba_1
XFILLER_36_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_199 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput27 i_wb_data[0] VGND VGND VPWR VPWR input27/X sky130_fd_sc_hd__clkbuf_1
Xinput16 i_wb_addr[1] VGND VGND VPWR VPWR _2540_/B sky130_fd_sc_hd__clkbuf_4
XFILLER_6_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput38 i_wb_data[1] VGND VGND VPWR VPWR input38/X sky130_fd_sc_hd__clkbuf_1
Xinput49 i_wb_data[2] VGND VGND VPWR VPWR input49/X sky130_fd_sc_hd__clkbuf_1
XFILLER_6_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2270_ _3204_/D VGND VGND VPWR VPWR _2271_/C sky130_fd_sc_hd__clkinv_2
XFILLER_77_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1985_ _3736_/Q _3737_/Q VGND VGND VPWR VPWR _2006_/A sky130_fd_sc_hd__nand2_1
X_3724_ _3725_/CLK _3724_/D VGND VGND VPWR VPWR _3724_/Q sky130_fd_sc_hd__dfxtp_4
X_3655_ _3860_/CLK _3655_/D VGND VGND VPWR VPWR _3655_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_9_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2606_ _2842_/C _2603_/X _2605_/X VGND VGND VPWR VPWR _2606_/Y sky130_fd_sc_hd__o21ai_1
X_3586_ _3898_/Q _3580_/Y _3585_/X _3402_/B VGND VGND VPWR VPWR _3898_/D sky130_fd_sc_hd__a22o_1
X_2537_ _2535_/X _2536_/X _2480_/Y _3732_/Q VGND VGND VPWR VPWR _2538_/D sky130_fd_sc_hd__a22o_1
X_2468_ _3122_/B _2762_/B _2468_/C VGND VGND VPWR VPWR _2468_/X sky130_fd_sc_hd__and3_1
X_2399_ _2399_/A _2766_/A VGND VGND VPWR VPWR _2399_/Y sky130_fd_sc_hd__nand2_1
XFILLER_43_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_239 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_147 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_236 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_291 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3440_ _3873_/Q _3870_/Q _3552_/S VGND VGND VPWR VPWR _3441_/B sky130_fd_sc_hd__mux2_1
X_3371_ _3898_/Q VGND VGND VPWR VPWR _3583_/B sky130_fd_sc_hd__inv_2
XFILLER_33_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2322_ _2362_/B VGND VGND VPWR VPWR _2367_/A sky130_fd_sc_hd__inv_2
X_2253_ _3657_/Q _3654_/Q _3826_/Q VGND VGND VPWR VPWR _2253_/X sky130_fd_sc_hd__mux2_1
XFILLER_69_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2184_ _2184_/A VGND VGND VPWR VPWR _2185_/B sky130_fd_sc_hd__inv_2
XFILLER_25_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1968_ input9/X _3737_/Q VGND VGND VPWR VPWR _1968_/X sky130_fd_sc_hd__xor2_1
X_3707_ _3849_/CLK _3707_/D VGND VGND VPWR VPWR _3707_/Q sky130_fd_sc_hd__dfxtp_1
X_1899_ _2113_/A _2187_/B _2364_/A VGND VGND VPWR VPWR _2139_/A sky130_fd_sc_hd__and3_1
X_3638_ _3839_/CLK _3638_/D VGND VGND VPWR VPWR _3638_/Q sky130_fd_sc_hd__dfxtp_1
X_3569_ _3571_/B _3553_/A _3411_/A VGND VGND VPWR VPWR _3569_/Y sky130_fd_sc_hd__a21oi_1
XFILLER_0_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_206 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2940_ _2940_/A _2940_/B VGND VGND VPWR VPWR _2940_/Y sky130_fd_sc_hd__nand2_1
XFILLER_62_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2871_ _3703_/Q VGND VGND VPWR VPWR _2884_/A sky130_fd_sc_hd__inv_2
X_1822_ _3367_/B _3367_/C VGND VGND VPWR VPWR _3306_/A sky130_fd_sc_hd__nor2_1
XFILLER_30_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3423_ _3568_/A _3423_/B VGND VGND VPWR VPWR _3423_/X sky130_fd_sc_hd__or2_1
XTAP_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3354_ _3853_/Q _2241_/X _3827_/D VGND VGND VPWR VPWR _3853_/D sky130_fd_sc_hd__mux2_1
XTAP_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3285_ _3607_/A VGND VGND VPWR VPWR _3611_/C sky130_fd_sc_hd__inv_2
X_2305_ _2957_/A _2305_/B _2380_/B VGND VGND VPWR VPWR _2306_/B sky130_fd_sc_hd__or3_1
X_2236_ _2235_/X _3649_/Q _2244_/S VGND VGND VPWR VPWR _3649_/D sky130_fd_sc_hd__mux2_1
XTAP_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2167_ input5/X VGND VGND VPWR VPWR _2168_/B sky130_fd_sc_hd__inv_2
X_2098_ _2098_/A _2098_/B _2098_/C VGND VGND VPWR VPWR _2099_/B sky130_fd_sc_hd__nand3_1
XFILLER_80_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_183 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_297 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3070_ _3132_/B _3068_/Y _2460_/Y _3069_/Y _2442_/C VGND VGND VPWR VPWR _3073_/B
+ sky130_fd_sc_hd__o2111a_1
XFILLER_39_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2021_ _2024_/A VGND VGND VPWR VPWR _2638_/A sky130_fd_sc_hd__inv_2
XFILLER_35_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_326 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2923_ _2923_/A VGND VGND VPWR VPWR _2926_/B sky130_fd_sc_hd__inv_2
X_2854_ _3013_/A _2854_/B _2854_/C _2854_/D VGND VGND VPWR VPWR _2857_/A sky130_fd_sc_hd__or4_1
X_2785_ _2785_/A _2785_/B VGND VGND VPWR VPWR _2785_/Y sky130_fd_sc_hd__nand2_1
X_3406_ _3585_/A _3606_/B VGND VGND VPWR VPWR _3406_/Y sky130_fd_sc_hd__nand2_8
X_3337_ _3836_/Q _2207_/X _3827_/D VGND VGND VPWR VPWR _3836_/D sky130_fd_sc_hd__mux2_1
XTAP_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_426 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3268_ _3270_/A _3855_/Q VGND VGND VPWR VPWR _3268_/X sky130_fd_sc_hd__and2_1
XTAP_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_418 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2219_ _3640_/Q _3637_/Q _3362_/S VGND VGND VPWR VPWR _2219_/X sky130_fd_sc_hd__mux2_1
X_3199_ _3199_/A _3199_/B _3199_/C VGND VGND VPWR VPWR _3202_/B sky130_fd_sc_hd__and3_1
XFILLER_26_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_172 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2570_ _2563_/Y _2565_/X _2567_/X _2569_/Y _2793_/A VGND VGND VPWR VPWR _2570_/X
+ sky130_fd_sc_hd__a41o_1
XFILLER_67_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3122_ _3122_/A _3122_/B _3122_/C VGND VGND VPWR VPWR _3122_/X sky130_fd_sc_hd__and3_1
XFILLER_55_407 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3053_ _3053_/A _3053_/B _3053_/C _3053_/D VGND VGND VPWR VPWR _3053_/X sky130_fd_sc_hd__or4_1
X_2004_ _2004_/A _2004_/B _2004_/C VGND VGND VPWR VPWR _2005_/B sky130_fd_sc_hd__nand3_1
XFILLER_23_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2906_ _3709_/Q _2914_/B _3022_/B _2905_/X VGND VGND VPWR VPWR _3709_/D sky130_fd_sc_hd__o211a_1
X_3886_ _3886_/CLK _3886_/D VGND VGND VPWR VPWR _3886_/Q sky130_fd_sc_hd__dfxtp_1
X_2837_ _2814_/Y _2845_/A _2836_/Y VGND VGND VPWR VPWR _3697_/D sky130_fd_sc_hd__o21ai_1
X_2768_ _3780_/Q VGND VGND VPWR VPWR _2860_/B sky130_fd_sc_hd__inv_2
XFILLER_2_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2699_ _3688_/Q VGND VGND VPWR VPWR _3528_/B sky130_fd_sc_hd__inv_2
XFILLER_58_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_87 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_156 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_75 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_418 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_82_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3740_ _3861_/CLK _3740_/D VGND VGND VPWR VPWR _3740_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_13_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3671_ _3890_/CLK _3671_/D VGND VGND VPWR VPWR _3671_/Q sky130_fd_sc_hd__dfxtp_1
X_2622_ _2619_/X _2620_/X _2621_/X _3739_/Q _2480_/Y VGND VGND VPWR VPWR _2622_/X
+ sky130_fd_sc_hd__a32o_1
XFILLER_63_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2553_ _2113_/A _2185_/A _3756_/Q _2782_/A VGND VGND VPWR VPWR _2553_/X sky130_fd_sc_hd__a31o_1
X_2484_ _3668_/Q VGND VGND VPWR VPWR _3405_/B sky130_fd_sc_hd__inv_2
X_3105_ _3122_/B _3105_/B VGND VGND VPWR VPWR _3105_/Y sky130_fd_sc_hd__nor2_1
XFILLER_55_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3036_ _3036_/A _3176_/B VGND VGND VPWR VPWR _3036_/Y sky130_fd_sc_hd__nor2_1
Xclkbuf_leaf_30_i_clk clkbuf_2_2__f_i_clk/X VGND VGND VPWR VPWR _3890_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_63_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3869_ _3874_/CLK _3869_/D VGND VGND VPWR VPWR _3869_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_19_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_229 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput17 i_wb_addr[2] VGND VGND VPWR VPWR _2549_/B sky130_fd_sc_hd__clkbuf_2
Xinput28 i_wb_data[10] VGND VGND VPWR VPWR input28/X sky130_fd_sc_hd__clkbuf_1
XFILLER_10_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput39 i_wb_data[20] VGND VGND VPWR VPWR input39/X sky130_fd_sc_hd__clkbuf_1
XFILLER_6_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1984_ _3738_/Q _3739_/Q VGND VGND VPWR VPWR _1986_/A sky130_fd_sc_hd__nand2_1
X_3723_ _3748_/CLK _3723_/D VGND VGND VPWR VPWR _3723_/Q sky130_fd_sc_hd__dfxtp_1
X_3654_ _3860_/CLK _3654_/D VGND VGND VPWR VPWR _3654_/Q sky130_fd_sc_hd__dfxtp_1
X_2605_ _3738_/Q _2948_/A _3032_/C _2604_/X VGND VGND VPWR VPWR _2605_/X sky130_fd_sc_hd__o211a_1
X_3585_ _3585_/A _3585_/B _3588_/A VGND VGND VPWR VPWR _3585_/X sky130_fd_sc_hd__or3_1
X_2536_ _3762_/Q _3058_/B VGND VGND VPWR VPWR _2536_/X sky130_fd_sc_hd__or2_2
X_2467_ _2467_/A _2796_/B VGND VGND VPWR VPWR _2468_/C sky130_fd_sc_hd__nor2_1
X_2398_ _2856_/A _2755_/C _3113_/D VGND VGND VPWR VPWR _2398_/X sky130_fd_sc_hd__or3_1
XFILLER_24_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_270 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3019_ _3173_/S VGND VGND VPWR VPWR _3165_/S sky130_fd_sc_hd__buf_12
XFILLER_11_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_432 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3370_ _3902_/Q _3903_/Q VGND VGND VPWR VPWR _3581_/B sky130_fd_sc_hd__nor2_1
X_2321_ _3056_/B _2752_/B VGND VGND VPWR VPWR _2321_/Y sky130_fd_sc_hd__nor2_1
X_2252_ _2251_/X _3657_/Q _3327_/B VGND VGND VPWR VPWR _3657_/D sky130_fd_sc_hd__mux2_1
XFILLER_26_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_192 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2183_ _3174_/A _2183_/B VGND VGND VPWR VPWR _2183_/Y sky130_fd_sc_hd__nor2_1
XFILLER_65_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1967_ _2104_/A _2055_/A _2004_/C _1966_/Y VGND VGND VPWR VPWR _1983_/A sky130_fd_sc_hd__o2bb2ai_1
X_3706_ _3706_/CLK _3706_/D VGND VGND VPWR VPWR _3706_/Q sky130_fd_sc_hd__dfxtp_1
X_1898_ _3696_/Q _2329_/B VGND VGND VPWR VPWR _2364_/A sky130_fd_sc_hd__nor2_1
X_3637_ _3839_/CLK _3637_/D VGND VGND VPWR VPWR _3637_/Q sky130_fd_sc_hd__dfxtp_1
X_3568_ _3568_/A _3568_/B VGND VGND VPWR VPWR _3568_/X sky130_fd_sc_hd__or2_1
XFILLER_68_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2519_ _2517_/X _2518_/X _2480_/Y _3730_/Q VGND VGND VPWR VPWR _2519_/X sky130_fd_sc_hd__a22o_1
X_3499_ _3556_/A _3680_/Q _3498_/Y _3406_/Y VGND VGND VPWR VPWR _3499_/X sky130_fd_sc_hd__a211o_1
XFILLER_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_376 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_88 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_435 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2870_ _2879_/A _2876_/S _2618_/Y VGND VGND VPWR VPWR _3702_/D sky130_fd_sc_hd__o21ai_1
X_1821_ _3307_/A VGND VGND VPWR VPWR _3367_/C sky130_fd_sc_hd__inv_2
XFILLER_7_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3422_ _3870_/Q _3867_/Q _3552_/S VGND VGND VPWR VPWR _3423_/B sky130_fd_sc_hd__mux2_1
XTAP_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3353_ _3852_/Q _2239_/X _3827_/D VGND VGND VPWR VPWR _3852_/D sky130_fd_sc_hd__mux2_1
XTAP_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3284_ _3552_/S _3556_/A _3284_/S VGND VGND VPWR VPWR _3819_/D sky130_fd_sc_hd__mux2_1
X_2304_ _2417_/A _3177_/A _3177_/B _2303_/X VGND VGND VPWR VPWR _2380_/B sky130_fd_sc_hd__o211a_1
XFILLER_57_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2235_ _3648_/Q _3645_/Q _3362_/S VGND VGND VPWR VPWR _2235_/X sky130_fd_sc_hd__mux2_1
XTAP_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2166_ _3700_/Q _2433_/B VGND VGND VPWR VPWR _2437_/B sky130_fd_sc_hd__nor2_1
XFILLER_38_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2097_ _2097_/A _2097_/B VGND VGND VPWR VPWR _2098_/C sky130_fd_sc_hd__nor2_1
XFILLER_21_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2999_ _3002_/A _3740_/Q VGND VGND VPWR VPWR _2999_/Y sky130_fd_sc_hd__nand2_1
XFILLER_0_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_198 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_453 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_427 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2020_ _2083_/A _2083_/B VGND VGND VPWR VPWR _2027_/A sky130_fd_sc_hd__nand2_1
XFILLER_82_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_173 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2922_ _3715_/Q _2924_/A VGND VGND VPWR VPWR _2923_/A sky130_fd_sc_hd__nor2_1
XFILLER_50_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2853_ _2899_/A _2853_/B VGND VGND VPWR VPWR _2853_/Y sky130_fd_sc_hd__nor2_1
X_2784_ _3032_/A _2478_/A _2856_/A VGND VGND VPWR VPWR _2785_/B sky130_fd_sc_hd__o21ai_1
X_3405_ _3559_/A _3405_/B VGND VGND VPWR VPWR _3405_/Y sky130_fd_sc_hd__nor2_1
X_3336_ _3835_/Q _2205_/X _3827_/D VGND VGND VPWR VPWR _3835_/D sky130_fd_sc_hd__mux2_1
XTAP_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3267_ _3266_/X _3815_/Q _3366_/S VGND VGND VPWR VPWR _3815_/D sky130_fd_sc_hd__mux2_1
XTAP_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_19 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2218_ _2217_/X _3640_/Q _2244_/S VGND VGND VPWR VPWR _3640_/D sky130_fd_sc_hd__mux2_1
X_3198_ _3844_/Q _3270_/A _3229_/A _3701_/Q VGND VGND VPWR VPWR _3198_/X sky130_fd_sc_hd__a22o_1
X_2149_ _3186_/A VGND VGND VPWR VPWR _3188_/A sky130_fd_sc_hd__inv_2
XFILLER_53_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3121_ _3121_/A _3121_/B VGND VGND VPWR VPWR _3122_/C sky130_fd_sc_hd__nand2_1
XFILLER_82_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3052_ _3202_/A _2825_/Y _3050_/X _3051_/X _2344_/Y VGND VGND VPWR VPWR _3084_/B
+ sky130_fd_sc_hd__a221o_1
XFILLER_55_419 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_290 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2003_ _2003_/A VGND VGND VPWR VPWR _2004_/B sky130_fd_sc_hd__inv_2
XFILLER_35_143 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3885_ _3890_/CLK _3885_/D VGND VGND VPWR VPWR _3885_/Q sky130_fd_sc_hd__dfxtp_1
X_2905_ _3831_/Q _3623_/A _2904_/Y _2901_/Y VGND VGND VPWR VPWR _2905_/X sky130_fd_sc_hd__a211o_1
X_2836_ _2845_/A _2836_/B VGND VGND VPWR VPWR _2836_/Y sky130_fd_sc_hd__nand2_1
XFILLER_31_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2767_ _2899_/A _2767_/B _2767_/C VGND VGND VPWR VPWR _2767_/Y sky130_fd_sc_hd__nor3_1
X_2698_ _2697_/X _3687_/Q _2793_/A VGND VGND VPWR VPWR _3687_/D sky130_fd_sc_hd__mux2_1
XFILLER_76_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3319_ _3319_/A _3552_/S _3818_/Q VGND VGND VPWR VPWR _3319_/X sky130_fd_sc_hd__and3_1
XTAP_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_99 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_48 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3670_ _3882_/CLK _3670_/D VGND VGND VPWR VPWR _3670_/Q sky130_fd_sc_hd__dfxtp_1
X_2621_ _3769_/Q _3058_/B VGND VGND VPWR VPWR _2621_/X sky130_fd_sc_hd__or2_1
X_2552_ _2608_/A _3677_/Q _2839_/A _3726_/Q _2856_/B VGND VGND VPWR VPWR _2556_/C
+ sky130_fd_sc_hd__a32o_1
X_2483_ _2482_/X _3667_/Q _2793_/A VGND VGND VPWR VPWR _3667_/D sky130_fd_sc_hd__mux2_1
XFILLER_28_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3104_ _3097_/X _3132_/B _3098_/X _3103_/Y VGND VGND VPWR VPWR _3104_/X sky130_fd_sc_hd__a31o_1
X_3035_ _3035_/A _3035_/B VGND VGND VPWR VPWR _3038_/A sky130_fd_sc_hd__nand2_1
XFILLER_36_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3868_ _3897_/CLK _3868_/D VGND VGND VPWR VPWR _3868_/Q sky130_fd_sc_hd__dfxtp_1
X_3799_ _3837_/CLK _3799_/D VGND VGND VPWR VPWR _3799_/Q sky130_fd_sc_hd__dfxtp_1
X_2819_ _2752_/B _3177_/A _2411_/Y _2850_/A _2818_/Y VGND VGND VPWR VPWR _2823_/B
+ sky130_fd_sc_hd__a41o_1
XFILLER_11_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_168 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput18 i_wb_addr[3] VGND VGND VPWR VPWR _2566_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_6_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput29 i_wb_data[11] VGND VGND VPWR VPWR input29/X sky130_fd_sc_hd__clkbuf_1
XFILLER_77_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1983_ _1983_/A _1983_/B _1983_/C VGND VGND VPWR VPWR _1983_/Y sky130_fd_sc_hd__nand3_1
X_3722_ _3748_/CLK _3722_/D VGND VGND VPWR VPWR _3722_/Q sky130_fd_sc_hd__dfxtp_1
X_3653_ _3861_/CLK _3653_/D VGND VGND VPWR VPWR _3653_/Q sky130_fd_sc_hd__dfxtp_1
X_2604_ _3752_/Q _2895_/B _3708_/Q _3057_/B VGND VGND VPWR VPWR _2604_/X sky130_fd_sc_hd__o22a_1
X_3584_ _3584_/A VGND VGND VPWR VPWR _3588_/A sky130_fd_sc_hd__inv_2
X_2535_ _2113_/A _2185_/A _3754_/Q _2782_/A VGND VGND VPWR VPWR _2535_/X sky130_fd_sc_hd__a31o_1
X_2466_ _3666_/Q VGND VGND VPWR VPWR _2467_/A sky130_fd_sc_hd__inv_2
X_2397_ _2948_/A _2397_/B VGND VGND VPWR VPWR _3113_/D sky130_fd_sc_hd__nand2_1
X_3018_ _3018_/A _3018_/B VGND VGND VPWR VPWR _3173_/S sky130_fd_sc_hd__nand2_4
XFILLER_36_282 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_219 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_164 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2320_ _3190_/A _3131_/B _2668_/B _2368_/A VGND VGND VPWR VPWR _2337_/A sky130_fd_sc_hd__or4b_1
X_2251_ _3656_/Q _3653_/Q _3826_/Q VGND VGND VPWR VPWR _2251_/X sky130_fd_sc_hd__mux2_1
XFILLER_2_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2182_ _2182_/A _2182_/B VGND VGND VPWR VPWR _2182_/Y sky130_fd_sc_hd__nand2_1
XFILLER_65_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1966_ _2102_/A VGND VGND VPWR VPWR _1966_/Y sky130_fd_sc_hd__inv_2
X_3705_ _3848_/CLK _3705_/D VGND VGND VPWR VPWR _3705_/Q sky130_fd_sc_hd__dfxtp_1
X_1897_ _3827_/Q VGND VGND VPWR VPWR _2329_/B sky130_fd_sc_hd__inv_2
X_3636_ _3706_/CLK _3636_/D VGND VGND VPWR VPWR _3636_/Q sky130_fd_sc_hd__dfxtp_1
X_3567_ _3894_/Q _3891_/Q _3607_/A VGND VGND VPWR VPWR _3568_/B sky130_fd_sc_hd__mux2_1
X_2518_ _3760_/Q _3058_/B VGND VGND VPWR VPWR _2518_/X sky130_fd_sc_hd__or2_1
X_3498_ _3559_/A _3498_/B VGND VGND VPWR VPWR _3498_/Y sky130_fd_sc_hd__nor2_1
XFILLER_75_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2449_ _2449_/A _3060_/B VGND VGND VPWR VPWR _2864_/A sky130_fd_sc_hd__nor2_1
XFILLER_71_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1820_ _3368_/B _3368_/C VGND VGND VPWR VPWR _3307_/A sky130_fd_sc_hd__nand2_2
X_3421_ _3556_/A _3667_/Q _3420_/X _3406_/Y VGND VGND VPWR VPWR _3421_/X sky130_fd_sc_hd__a211o_1
X_3352_ _3851_/Q _2237_/X _3827_/D VGND VGND VPWR VPWR _3851_/D sky130_fd_sc_hd__mux2_1
XTAP_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2303_ _2303_/A _2453_/B _3138_/C VGND VGND VPWR VPWR _2303_/X sky130_fd_sc_hd__and3_1
XTAP_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3283_ _3607_/A VGND VGND VPWR VPWR _3552_/S sky130_fd_sc_hd__clkbuf_16
XTAP_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2234_ _2233_/X _3648_/Q _2244_/S VGND VGND VPWR VPWR _3648_/D sky130_fd_sc_hd__mux2_1
X_2165_ _2165_/A VGND VGND VPWR VPWR _2433_/B sky130_fd_sc_hd__inv_2
XFILLER_38_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2096_ _2096_/A _2096_/B VGND VGND VPWR VPWR _2097_/B sky130_fd_sc_hd__nand2_1
XFILLER_21_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2998_ _2996_/Y _2960_/X _2997_/Y VGND VGND VPWR VPWR _3739_/D sky130_fd_sc_hd__o21ai_1
X_1949_ _3203_/B _3174_/A VGND VGND VPWR VPWR _1949_/Y sky130_fd_sc_hd__nor2_1
X_3619_ _3619_/A _3619_/B _3619_/C VGND VGND VPWR VPWR _3624_/B sky130_fd_sc_hd__and3_1
XFILLER_76_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2921_ _2924_/A _2920_/Y _2941_/A VGND VGND VPWR VPWR _3714_/D sky130_fd_sc_hd__a21oi_1
XFILLER_62_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2852_ _3204_/A _3034_/B _2863_/B VGND VGND VPWR VPWR _2853_/B sky130_fd_sc_hd__or3_1
X_2783_ _3744_/Q VGND VGND VPWR VPWR _3032_/A sky130_fd_sc_hd__inv_2
XFILLER_7_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3404_ _3668_/Q _3606_/B _3868_/Q _3390_/Y _3403_/X VGND VGND VPWR VPWR _3868_/D
+ sky130_fd_sc_hd__o221a_1
X_3335_ _3834_/Q _2203_/X _3827_/D VGND VGND VPWR VPWR _3834_/D sky130_fd_sc_hd__mux2_1
XTAP_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3266_ _3270_/A _3854_/Q VGND VGND VPWR VPWR _3266_/X sky130_fd_sc_hd__and2_1
XTAP_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2217_ _3639_/Q _3636_/Q _3362_/S VGND VGND VPWR VPWR _2217_/X sky130_fd_sc_hd__mux2_1
XFILLER_38_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3197_ _3197_/A _3197_/B VGND VGND VPWR VPWR _3229_/A sky130_fd_sc_hd__nand2_8
XFILLER_53_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2148_ _2148_/A _3053_/C VGND VGND VPWR VPWR _3186_/A sky130_fd_sc_hd__nor2_1
X_2079_ _2079_/A _2103_/A VGND VGND VPWR VPWR _2081_/A sky130_fd_sc_hd__nand2_1
XFILLER_81_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3120_ _3196_/B _2724_/Y _3011_/B _3011_/A _3197_/A VGND VGND VPWR VPWR _3120_/X
+ sky130_fd_sc_hd__o311a_1
X_3051_ _2429_/B _2779_/B _2742_/B VGND VGND VPWR VPWR _3051_/X sky130_fd_sc_hd__o21a_1
XFILLER_48_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2002_ _2002_/A _2003_/A VGND VGND VPWR VPWR _2005_/A sky130_fd_sc_hd__nand2_1
XFILLER_35_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_188 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_114 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3884_ _3890_/CLK _3884_/D VGND VGND VPWR VPWR _3884_/Q sky130_fd_sc_hd__dfxtp_1
X_2904_ _2904_/A _3623_/A VGND VGND VPWR VPWR _2904_/Y sky130_fd_sc_hd__nor2_1
X_2835_ _3105_/B _3084_/A _2835_/C _2835_/D VGND VGND VPWR VPWR _2836_/B sky130_fd_sc_hd__or4_1
X_2766_ _2766_/A VGND VGND VPWR VPWR _2767_/C sky130_fd_sc_hd__inv_2
X_2697_ _2863_/A _2574_/Y _2690_/Y _2692_/Y _2696_/X VGND VGND VPWR VPWR _2697_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_6_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3318_ _3825_/Q _1835_/B _3317_/X VGND VGND VPWR VPWR _3318_/X sky130_fd_sc_hd__a21o_1
XTAP_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3249_ _3248_/X _3806_/Q _3263_/S VGND VGND VPWR VPWR _3806_/D sky130_fd_sc_hd__mux2_1
XFILLER_73_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_287 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_100 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_40 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2620_ _3753_/Q _2895_/B _3709_/Q _3057_/B VGND VGND VPWR VPWR _2620_/X sky130_fd_sc_hd__o22a_1
X_2551_ _2551_/A _3122_/B VGND VGND VPWR VPWR _2556_/B sky130_fd_sc_hd__and2_1
X_2482_ _3122_/B _2473_/X _2608_/A _2472_/Y _2481_/X VGND VGND VPWR VPWR _2482_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_49_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3103_ _3100_/X _3102_/X _3011_/B VGND VGND VPWR VPWR _3103_/Y sky130_fd_sc_hd__a21oi_1
X_3034_ _3196_/A _3034_/B VGND VGND VPWR VPWR _3035_/B sky130_fd_sc_hd__nor2_1
XFILLER_51_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3867_ _3897_/CLK _3867_/D VGND VGND VPWR VPWR _3867_/Q sky130_fd_sc_hd__dfxtp_1
X_3798_ _3837_/CLK _3798_/D VGND VGND VPWR VPWR _3798_/Q sky130_fd_sc_hd__dfxtp_1
X_2818_ _2818_/A _3090_/B VGND VGND VPWR VPWR _2818_/Y sky130_fd_sc_hd__nand2_1
X_2749_ _2749_/A _2788_/B VGND VGND VPWR VPWR _2754_/A sky130_fd_sc_hd__nor2_1
XTAP_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput19 i_wb_addr[4] VGND VGND VPWR VPWR _2577_/B sky130_fd_sc_hd__buf_2
XFILLER_6_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1982_ _2006_/B _1980_/Y _1981_/Y VGND VGND VPWR VPWR _1983_/C sky130_fd_sc_hd__o21ai_1
X_3721_ _3748_/CLK _3721_/D VGND VGND VPWR VPWR _3721_/Q sky130_fd_sc_hd__dfxtp_1
X_3652_ _3861_/CLK _3652_/D VGND VGND VPWR VPWR _3652_/Q sky130_fd_sc_hd__dfxtp_1
X_3583_ _3583_/A _3583_/B VGND VGND VPWR VPWR _3584_/A sky130_fd_sc_hd__nand2_1
X_2603_ _3768_/Q _3058_/B _2601_/Y _2619_/A VGND VGND VPWR VPWR _2603_/X sky130_fd_sc_hd__o22a_1
X_2534_ _2608_/A _3675_/Q _2839_/A _3724_/Q _2856_/B VGND VGND VPWR VPWR _2538_/C
+ sky130_fd_sc_hd__a32o_1
X_2465_ _2406_/X _3665_/Q _2793_/A VGND VGND VPWR VPWR _3665_/D sky130_fd_sc_hd__mux2_1
X_2396_ _2842_/C VGND VGND VPWR VPWR _2948_/A sky130_fd_sc_hd__inv_2
XFILLER_68_397 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3017_ _3017_/A _3017_/B _3017_/C _3017_/D VGND VGND VPWR VPWR _3018_/A sky130_fd_sc_hd__and4_1
XFILLER_24_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_294 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2250_ _2249_/X _3656_/Q _3327_/B VGND VGND VPWR VPWR _3656_/D sky130_fd_sc_hd__mux2_1
XFILLER_69_128 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2181_ _3044_/B _2160_/X _2164_/X _2180_/Y VGND VGND VPWR VPWR _2182_/B sky130_fd_sc_hd__a211oi_1
XFILLER_18_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_272 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1965_ _2610_/A _3730_/Q _1963_/A VGND VGND VPWR VPWR _2102_/A sky130_fd_sc_hd__o21ai_1
X_3704_ _3849_/CLK _3704_/D VGND VGND VPWR VPWR _3704_/Q sky130_fd_sc_hd__dfxtp_1
X_1896_ _1896_/A VGND VGND VPWR VPWR _2113_/A sky130_fd_sc_hd__buf_4
X_3635_ _3706_/CLK _3635_/D VGND VGND VPWR VPWR _3635_/Q sky130_fd_sc_hd__dfxtp_1
X_3566_ _3556_/A _3691_/Q _3565_/Y _3406_/Y VGND VGND VPWR VPWR _3566_/X sky130_fd_sc_hd__a211o_1
X_3497_ _3493_/X _3495_/X _3496_/Y _3883_/Q _3577_/A VGND VGND VPWR VPWR _3883_/D
+ sky130_fd_sc_hd__a32o_1
X_2517_ _2113_/A _2185_/A _3752_/Q _2782_/A VGND VGND VPWR VPWR _2517_/X sky130_fd_sc_hd__a31o_1
X_2448_ _2448_/A _2728_/B _3060_/B _2448_/D VGND VGND VPWR VPWR _2821_/C sky130_fd_sc_hd__or4_1
X_2379_ _2766_/A _3029_/B VGND VGND VPWR VPWR _2379_/Y sky130_fd_sc_hd__nand2_1
XFILLER_68_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_63 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3420_ _3555_/A _3670_/Q VGND VGND VPWR VPWR _3420_/X sky130_fd_sc_hd__and2_1
X_3351_ _3850_/Q _2235_/X _3827_/D VGND VGND VPWR VPWR _3850_/D sky130_fd_sc_hd__mux2_1
XFILLER_31_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2302_ _3023_/A VGND VGND VPWR VPWR _2453_/B sky130_fd_sc_hd__clkinv_2
XTAP_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3282_ _3819_/Q VGND VGND VPWR VPWR _3607_/A sky130_fd_sc_hd__buf_6
XTAP_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2233_ _3647_/Q _3644_/Q _3362_/S VGND VGND VPWR VPWR _2233_/X sky130_fd_sc_hd__mux2_1
XTAP_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2164_ _2863_/A _2164_/B _2425_/A VGND VGND VPWR VPWR _2164_/X sky130_fd_sc_hd__and3_1
XFILLER_38_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2095_ _2095_/A _2104_/B _2106_/A VGND VGND VPWR VPWR _2096_/B sky130_fd_sc_hd__nand3_1
XFILLER_65_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_201 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2997_ _3002_/A _3739_/Q VGND VGND VPWR VPWR _2997_/Y sky130_fd_sc_hd__nand2_1
XFILLER_21_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1948_ _3827_/Q _2293_/A VGND VGND VPWR VPWR _3174_/A sky130_fd_sc_hd__nor2_2
X_1879_ _3199_/B VGND VGND VPWR VPWR _2437_/A sky130_fd_sc_hd__inv_2
X_3618_ _3618_/A _3618_/B VGND VGND VPWR VPWR _3619_/C sky130_fd_sc_hd__or2_1
XFILLER_0_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3549_ _3568_/A _3549_/B VGND VGND VPWR VPWR _3549_/X sky130_fd_sc_hd__or2_1
XFILLER_28_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_378 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_223 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2920_ _3022_/A _3714_/Q VGND VGND VPWR VPWR _2920_/Y sky130_fd_sc_hd__nand2_1
X_2851_ _2752_/B _2376_/C _2417_/A VGND VGND VPWR VPWR _2851_/Y sky130_fd_sc_hd__a21oi_1
X_2782_ _2782_/A _3781_/Q VGND VGND VPWR VPWR _2782_/Y sky130_fd_sc_hd__nand2_1
XFILLER_7_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3403_ _3667_/Q _3391_/Y _3402_/Y VGND VGND VPWR VPWR _3403_/X sky130_fd_sc_hd__a21o_1
X_3334_ _3833_/Q _2201_/X _3827_/D VGND VGND VPWR VPWR _3833_/D sky130_fd_sc_hd__mux2_1
XTAP_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3265_ _3264_/X _3814_/Q _3366_/S VGND VGND VPWR VPWR _3814_/D sky130_fd_sc_hd__mux2_1
XTAP_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2216_ _2215_/X _3639_/Q _2244_/S VGND VGND VPWR VPWR _3639_/D sky130_fd_sc_hd__mux2_1
XTAP_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3196_ _3196_/A _3196_/B VGND VGND VPWR VPWR _3197_/B sky130_fd_sc_hd__nand2_2
XFILLER_38_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2147_ _2285_/A _3046_/B VGND VGND VPWR VPWR _3053_/C sky130_fd_sc_hd__nand2_1
X_2078_ _2080_/C VGND VGND VPWR VPWR _2103_/A sky130_fd_sc_hd__inv_2
XFILLER_14_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_458 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3050_ _2171_/A _3106_/A _2175_/A _2170_/B VGND VGND VPWR VPWR _3050_/X sky130_fd_sc_hd__a211o_1
X_2001_ _2004_/A _2004_/C VGND VGND VPWR VPWR _2002_/A sky130_fd_sc_hd__nand2_1
XFILLER_35_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3883_ _3886_/CLK _3883_/D VGND VGND VPWR VPWR _3883_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_31_340 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2903_ _2894_/X _2901_/Y _3022_/B _2902_/X VGND VGND VPWR VPWR _3708_/D sky130_fd_sc_hd__o211a_1
X_2834_ _3044_/B _2828_/Y _2830_/Y _2832_/Y _2833_/X VGND VGND VPWR VPWR _2835_/D
+ sky130_fd_sc_hd__a2111o_1
X_2765_ _2839_/A _2810_/B _3693_/Q _2729_/A _3099_/A VGND VGND VPWR VPWR _2765_/X
+ sky130_fd_sc_hd__a32o_1
X_2696_ _3736_/Q _2856_/B _2608_/A _2692_/Y _2695_/X VGND VGND VPWR VPWR _2696_/X
+ sky130_fd_sc_hd__a221o_1
X_3317_ _3367_/B _3664_/Q _3571_/A VGND VGND VPWR VPWR _3317_/X sky130_fd_sc_hd__and3_1
XTAP_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3248_ _3270_/A _3839_/Q VGND VGND VPWR VPWR _3248_/X sky130_fd_sc_hd__and2_1
XTAP_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3179_ _2112_/Y _3138_/C _3076_/B VGND VGND VPWR VPWR _3179_/Y sky130_fd_sc_hd__a21oi_1
XPHY_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_262 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2550_ _2839_/A _2762_/B _3677_/Q input6/X _3121_/A VGND VGND VPWR VPWR _2551_/A
+ sky130_fd_sc_hd__a32o_1
X_2481_ _3754_/Q _2782_/A _2480_/Y _3724_/Q VGND VGND VPWR VPWR _2481_/X sky130_fd_sc_hd__a22o_1
X_3102_ _3101_/Y _3699_/Q _3745_/Q _3099_/B VGND VGND VPWR VPWR _3102_/X sky130_fd_sc_hd__a31o_1
X_3033_ _3033_/A _3033_/B VGND VGND VPWR VPWR _3035_/A sky130_fd_sc_hd__nand2_1
XFILLER_55_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_402 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3866_ _3897_/CLK _3866_/D VGND VGND VPWR VPWR _3866_/Q sky130_fd_sc_hd__dfxtp_1
X_3797_ _3837_/CLK _3797_/D VGND VGND VPWR VPWR _3797_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_11_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2817_ _2817_/A _2817_/B VGND VGND VPWR VPWR _2818_/A sky130_fd_sc_hd__and2_1
X_2748_ _3202_/A _2747_/X _2460_/B _2438_/Y VGND VGND VPWR VPWR _2759_/B sky130_fd_sc_hd__a22o_1
X_2679_ _2608_/A _3686_/Q _2839_/A _3735_/Q _2856_/B VGND VGND VPWR VPWR _2679_/X
+ sky130_fd_sc_hd__a32o_1
XTAP_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_424 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3720_ _3748_/CLK _3720_/D VGND VGND VPWR VPWR _3720_/Q sky130_fd_sc_hd__dfxtp_1
X_1981_ _1968_/X _2006_/B _1977_/Y VGND VGND VPWR VPWR _1981_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_60_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3651_ _3861_/CLK _3651_/D VGND VGND VPWR VPWR _3651_/Q sky130_fd_sc_hd__dfxtp_1
X_3582_ _3583_/B _3583_/A VGND VGND VPWR VPWR _3585_/B sky130_fd_sc_hd__nor2_1
X_2602_ _2713_/A _3058_/B VGND VGND VPWR VPWR _2619_/A sky130_fd_sc_hd__nand2_1
X_2533_ _2533_/A _3122_/B VGND VGND VPWR VPWR _2538_/B sky130_fd_sc_hd__and2_1
X_2464_ _2803_/S VGND VGND VPWR VPWR _2793_/A sky130_fd_sc_hd__buf_12
X_2395_ _2395_/A _2949_/A _2453_/A _2395_/D VGND VGND VPWR VPWR _2395_/X sky130_fd_sc_hd__and4_1
XFILLER_68_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_332 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3016_ _3016_/A _3016_/B _3131_/B _3046_/B VGND VGND VPWR VPWR _3017_/D sky130_fd_sc_hd__and4_1
X_3849_ _3849_/CLK _3849_/D VGND VGND VPWR VPWR _3849_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_47_22 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_240 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2180_ _3700_/Q _2762_/B _2176_/Y _2179_/X _3049_/B VGND VGND VPWR VPWR _2180_/Y
+ sky130_fd_sc_hd__a221oi_1
XFILLER_65_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1964_ _2083_/A _1964_/B VGND VGND VPWR VPWR _2004_/C sky130_fd_sc_hd__nand2_1
X_3703_ _3849_/CLK _3703_/D VGND VGND VPWR VPWR _3703_/Q sky130_fd_sc_hd__dfxtp_1
X_3634_ _3706_/CLK _3634_/D VGND VGND VPWR VPWR _3634_/Q sky130_fd_sc_hd__dfxtp_1
X_1895_ _2140_/A _2114_/A VGND VGND VPWR VPWR _1896_/A sky130_fd_sc_hd__and2_1
X_3565_ _3571_/A _3565_/B VGND VGND VPWR VPWR _3565_/Y sky130_fd_sc_hd__nor2_1
XFILLER_0_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2516_ _1955_/A _3121_/A _2515_/Y _2762_/B VGND VGND VPWR VPWR _2516_/X sky130_fd_sc_hd__a22o_1
X_3496_ _3498_/B _3553_/A _3411_/A VGND VGND VPWR VPWR _3496_/Y sky130_fd_sc_hd__a21oi_1
X_2447_ _3044_/B _2447_/B VGND VGND VPWR VPWR _2448_/D sky130_fd_sc_hd__nand2_1
XFILLER_68_162 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2378_ _2854_/B _3829_/Q VGND VGND VPWR VPWR _3029_/B sky130_fd_sc_hd__nand2_1
XFILLER_56_346 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_316 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_173 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3350_ _3849_/Q _2233_/X _3827_/D VGND VGND VPWR VPWR _3849_/D sky130_fd_sc_hd__mux2_1
X_2301_ _2301_/A _3053_/D _2301_/C VGND VGND VPWR VPWR _2303_/A sky130_fd_sc_hd__nor3_1
XTAP_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3281_ _3818_/Q _3664_/Q _3284_/S VGND VGND VPWR VPWR _3818_/D sky130_fd_sc_hd__mux2_1
XFILLER_2_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2232_ _2231_/X _3647_/Q _2244_/S VGND VGND VPWR VPWR _3647_/D sky130_fd_sc_hd__mux2_1
XTAP_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2163_ _2369_/B VGND VGND VPWR VPWR _2425_/A sky130_fd_sc_hd__inv_2
XFILLER_53_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2094_ _2094_/A _2094_/B VGND VGND VPWR VPWR _2096_/A sky130_fd_sc_hd__nand2_1
XFILLER_0_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_360 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_246 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2996_ _2996_/A VGND VGND VPWR VPWR _2996_/Y sky130_fd_sc_hd__inv_2
X_1947_ _1947_/A _2949_/A VGND VGND VPWR VPWR _3203_/B sky130_fd_sc_hd__nor2_1
X_1878_ _2540_/B input5/X VGND VGND VPWR VPWR _3199_/B sky130_fd_sc_hd__nor2_2
X_3617_ _3623_/A _3835_/Q VGND VGND VPWR VPWR _3617_/X sky130_fd_sc_hd__and2_1
X_3548_ _3891_/Q _3888_/Q _3607_/A VGND VGND VPWR VPWR _3549_/B sky130_fd_sc_hd__mux2_1
X_3479_ _3475_/X _3477_/X _3478_/Y _3880_/Q _3577_/A VGND VGND VPWR VPWR _3880_/D
+ sky130_fd_sc_hd__a32o_1
XFILLER_69_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_75 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_360 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2850_ _2850_/A _2850_/B VGND VGND VPWR VPWR _3618_/B sky130_fd_sc_hd__nand2_1
X_2781_ _3177_/B _3058_/B VGND VGND VPWR VPWR _2781_/Y sky130_fd_sc_hd__nand2_1
X_3402_ _3402_/A _3402_/B VGND VGND VPWR VPWR _3402_/Y sky130_fd_sc_hd__nand2_1
XTAP_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3333_ _3832_/Q _2199_/X _3827_/D VGND VGND VPWR VPWR _3832_/D sky130_fd_sc_hd__mux2_1
XTAP_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3264_ _3270_/A _3853_/Q VGND VGND VPWR VPWR _3264_/X sky130_fd_sc_hd__and2_1
XTAP_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2215_ _3638_/Q _3635_/Q _3362_/S VGND VGND VPWR VPWR _2215_/X sky130_fd_sc_hd__mux2_1
XTAP_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3195_ _3722_/Q _3717_/Q _3195_/C VGND VGND VPWR VPWR _3786_/D sky130_fd_sc_hd__or3_1
XFILLER_26_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2146_ _2681_/B _2187_/B VGND VGND VPWR VPWR _3046_/B sky130_fd_sc_hd__nand2_4
X_2077_ _2996_/A _3739_/Q VGND VGND VPWR VPWR _2080_/C sky130_fd_sc_hd__xor2_1
XFILLER_53_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2979_ _2638_/A _2960_/X _2978_/Y VGND VGND VPWR VPWR _3732_/D sky130_fd_sc_hd__o21ai_1
XFILLER_30_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_408 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_22 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_44 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_441 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2000_ _2059_/B _2000_/B VGND VGND VPWR VPWR _2004_/A sky130_fd_sc_hd__nand2_1
XFILLER_16_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2902_ _3708_/Q _2914_/B VGND VGND VPWR VPWR _2902_/X sky130_fd_sc_hd__or2_1
X_3882_ _3882_/CLK _3882_/D VGND VGND VPWR VPWR _3882_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_31_352 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2833_ _2833_/A _2833_/B VGND VGND VPWR VPWR _2833_/X sky130_fd_sc_hd__or2_1
X_2764_ _2764_/A VGND VGND VPWR VPWR _3099_/A sky130_fd_sc_hd__inv_2
X_2695_ _2842_/A _3905_/Q _2693_/Y _2694_/X VGND VGND VPWR VPWR _2695_/X sky130_fd_sc_hd__a211o_1
XFILLER_6_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3316_ _3313_/X _3824_/Q _3316_/S VGND VGND VPWR VPWR _3824_/D sky130_fd_sc_hd__mux2_1
XTAP_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3247_ _3246_/X _3805_/Q _3263_/S VGND VGND VPWR VPWR _3805_/D sky130_fd_sc_hd__mux2_1
XTAP_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3178_ _3177_/Y _3076_/B _3023_/A _2266_/A VGND VGND VPWR VPWR _3178_/Y sky130_fd_sc_hd__a211oi_1
XFILLER_66_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2129_ _2856_/A VGND VGND VPWR VPWR _3032_/C sky130_fd_sc_hd__inv_4
XFILLER_81_252 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_116 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_267 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_274 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2480_ _2480_/A VGND VGND VPWR VPWR _2480_/Y sky130_fd_sc_hd__clkinv_4
XFILLER_56_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput90 _3793_/Q VGND VGND VPWR VPWR o_wb_data[27] sky130_fd_sc_hd__clkbuf_1
X_3101_ _3700_/Q VGND VGND VPWR VPWR _3101_/Y sky130_fd_sc_hd__inv_2
X_3032_ _3032_/A _3032_/B _3032_/C VGND VGND VPWR VPWR _3033_/B sky130_fd_sc_hd__or3_1
XFILLER_36_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3865_ _3865_/CLK _3865_/D VGND VGND VPWR VPWR _3865_/Q sky130_fd_sc_hd__dfxtp_2
X_2816_ _2815_/Y _2816_/B _2816_/C VGND VGND VPWR VPWR _2823_/A sky130_fd_sc_hd__nand3b_1
X_3796_ _3862_/CLK _3796_/D VGND VGND VPWR VPWR _3796_/Q sky130_fd_sc_hd__dfxtp_1
X_2747_ _2797_/A _2747_/B VGND VGND VPWR VPWR _2747_/X sky130_fd_sc_hd__or2_1
X_2678_ _3049_/B _2678_/B VGND VGND VPWR VPWR _2678_/Y sky130_fd_sc_hd__nor2_1
XTAP_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_425 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1980_ input8/X _1976_/B _1968_/X VGND VGND VPWR VPWR _1980_/Y sky130_fd_sc_hd__a21oi_1
XFILLER_60_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3650_ _3861_/CLK _3650_/D VGND VGND VPWR VPWR _3650_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_9_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3581_ _3607_/A _3581_/B VGND VGND VPWR VPWR _3583_/A sky130_fd_sc_hd__or2_1
X_2601_ _2601_/A _2752_/B VGND VGND VPWR VPWR _2601_/Y sky130_fd_sc_hd__nor2_1
X_2532_ _2839_/A _2762_/B _3675_/Q _2024_/A _3121_/A VGND VGND VPWR VPWR _2533_/A
+ sky130_fd_sc_hd__a32o_1
XFILLER_54_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2463_ _2463_/A _2463_/B VGND VGND VPWR VPWR _2803_/S sky130_fd_sc_hd__nand2_4
X_2394_ _2822_/A _2394_/B VGND VGND VPWR VPWR _2395_/D sky130_fd_sc_hd__nor2_1
X_3015_ _3009_/X _3744_/Q _3015_/S VGND VGND VPWR VPWR _3744_/D sky130_fd_sc_hd__mux2_1
XFILLER_36_230 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_299 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3848_ _3848_/CLK _3848_/D VGND VGND VPWR VPWR _3848_/Q sky130_fd_sc_hd__dfxtp_1
X_3779_ _3837_/CLK _3779_/D VGND VGND VPWR VPWR _3779_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_3_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_34 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1963_ _1963_/A _2083_/A _1964_/B VGND VGND VPWR VPWR _2055_/A sky130_fd_sc_hd__nand3_1
X_1894_ _3749_/Q _1894_/B VGND VGND VPWR VPWR _2114_/A sky130_fd_sc_hd__nor2_1
X_3702_ _3846_/CLK _3702_/D VGND VGND VPWR VPWR _3702_/Q sky130_fd_sc_hd__dfxtp_1
X_3633_ _3706_/CLK _3633_/D VGND VGND VPWR VPWR _3633_/Q sky130_fd_sc_hd__dfxtp_1
X_3564_ _3560_/X _3562_/X _3563_/Y _3894_/Q _3577_/A VGND VGND VPWR VPWR _3894_/D
+ sky130_fd_sc_hd__a32o_1
X_2515_ _3438_/B _2796_/B VGND VGND VPWR VPWR _2515_/Y sky130_fd_sc_hd__nor2_1
X_3495_ _3568_/A _3495_/B VGND VGND VPWR VPWR _3495_/X sky130_fd_sc_hd__or2_1
X_2446_ _2449_/A VGND VGND VPWR VPWR _2447_/B sky130_fd_sc_hd__inv_2
XFILLER_68_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2377_ _3662_/Q _2374_/X _2377_/S VGND VGND VPWR VPWR _3662_/D sky130_fd_sc_hd__mux2_1
XFILLER_68_174 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_383 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3280_ _3322_/A _3389_/B _3379_/B VGND VGND VPWR VPWR _3284_/S sky130_fd_sc_hd__and3_1
X_2300_ _3131_/C _2300_/B _2766_/A VGND VGND VPWR VPWR _2301_/C sky130_fd_sc_hd__nand3_1
XTAP_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2231_ _3646_/Q _3643_/Q _3362_/S VGND VGND VPWR VPWR _2231_/X sky130_fd_sc_hd__mux2_1
XTAP_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2162_ _2174_/A _2435_/A VGND VGND VPWR VPWR _2369_/B sky130_fd_sc_hd__nor2_2
XFILLER_38_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2093_ _2093_/A _2093_/B VGND VGND VPWR VPWR _2097_/A sky130_fd_sc_hd__nand2_1
XFILLER_80_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_372 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_258 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2995_ _2993_/Y _2960_/X _2994_/Y VGND VGND VPWR VPWR _3738_/D sky130_fd_sc_hd__o21ai_1
X_1946_ _2134_/B VGND VGND VPWR VPWR _1947_/A sky130_fd_sc_hd__inv_2
X_1877_ _2720_/B VGND VGND VPWR VPWR _2762_/B sky130_fd_sc_hd__clkinv_8
X_3616_ _3615_/B _3611_/X _3606_/X _3614_/X _3615_/Y VGND VGND VPWR VPWR _3903_/D
+ sky130_fd_sc_hd__a221o_1
X_3547_ _3556_/A _3688_/Q _3546_/Y _3406_/Y VGND VGND VPWR VPWR _3547_/X sky130_fd_sc_hd__a211o_1
XFILLER_0_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3478_ _3480_/B _3553_/A _3411_/A VGND VGND VPWR VPWR _3478_/Y sky130_fd_sc_hd__a21oi_1
X_2429_ _2437_/A _2429_/B VGND VGND VPWR VPWR _2430_/B sky130_fd_sc_hd__nor2_1
XFILLER_29_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_18 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_87 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_475 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_91 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2780_ _2778_/Y _2779_/Y _3049_/B VGND VGND VPWR VPWR _2780_/Y sky130_fd_sc_hd__a21oi_1
X_3401_ _3552_/S _3585_/A _3867_/Q VGND VGND VPWR VPWR _3402_/A sky130_fd_sc_hd__or3b_1
X_3332_ _3831_/Q _2197_/X _3827_/D VGND VGND VPWR VPWR _3831_/D sky130_fd_sc_hd__mux2_1
XTAP_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3263_ _3262_/X _3813_/Q _3263_/S VGND VGND VPWR VPWR _3813_/D sky130_fd_sc_hd__mux2_1
XTAP_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2214_ _2213_/X _3638_/Q _2244_/S VGND VGND VPWR VPWR _3638_/D sky130_fd_sc_hd__mux2_1
X_3194_ _1890_/A _3020_/A _3165_/S _3099_/B VGND VGND VPWR VPWR _3785_/D sky130_fd_sc_hd__a22o_1
XTAP_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2145_ _3013_/A VGND VGND VPWR VPWR _2285_/A sky130_fd_sc_hd__inv_2
XFILLER_38_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2076_ _2080_/A _3738_/Q VGND VGND VPWR VPWR _2079_/A sky130_fd_sc_hd__nand2_1
XFILLER_34_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_191 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2978_ _3002_/A _3732_/Q VGND VGND VPWR VPWR _2978_/Y sky130_fd_sc_hd__nand2_1
X_1929_ _1929_/A VGND VGND VPWR VPWR _2856_/A sky130_fd_sc_hd__buf_6
XFILLER_30_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_239 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2901_ _2914_/B VGND VGND VPWR VPWR _2901_/Y sky130_fd_sc_hd__clkinv_2
X_3881_ _3886_/CLK _3881_/D VGND VGND VPWR VPWR _3881_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_43_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_364 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2832_ _2832_/A _2832_/B VGND VGND VPWR VPWR _2832_/Y sky130_fd_sc_hd__nand2_1
X_2763_ input5/X _3199_/C _3049_/B _2762_/X VGND VGND VPWR VPWR _2763_/X sky130_fd_sc_hd__a211o_1
X_2694_ _2782_/A _3774_/Q VGND VGND VPWR VPWR _2694_/X sky130_fd_sc_hd__and2_1
XTAP_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3315_ _3314_/A _1828_/Y _3314_/Y VGND VGND VPWR VPWR _3316_/S sky130_fd_sc_hd__o21ai_1
XTAP_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3246_ _3270_/A _3838_/Q VGND VGND VPWR VPWR _3246_/X sky130_fd_sc_hd__and2_1
XTAP_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3177_ _3177_/A _3177_/B VGND VGND VPWR VPWR _3177_/Y sky130_fd_sc_hd__nand2_1
XFILLER_81_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2128_ _3034_/B _3623_/A VGND VGND VPWR VPWR _2850_/B sky130_fd_sc_hd__nor2_1
XFILLER_81_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2059_ _2059_/A _2059_/B VGND VGND VPWR VPWR _2060_/A sky130_fd_sc_hd__nand2_1
XPHY_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_286 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput91 _3794_/Q VGND VGND VPWR VPWR o_wb_data[28] sky130_fd_sc_hd__clkbuf_1
Xoutput80 _3791_/Q VGND VGND VPWR VPWR o_wb_data[18] sky130_fd_sc_hd__clkbuf_1
X_3100_ _3745_/Q _3724_/Q _2728_/B _3099_/Y VGND VGND VPWR VPWR _3100_/X sky130_fd_sc_hd__a31o_1
X_3031_ _3031_/A _3031_/B VGND VGND VPWR VPWR _3033_/A sky130_fd_sc_hd__nand2_1
XFILLER_36_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3864_ _3901_/CLK _3864_/D VGND VGND VPWR VPWR _3864_/Q sky130_fd_sc_hd__dfxtp_2
X_2815_ _3022_/A _2815_/B VGND VGND VPWR VPWR _2815_/Y sky130_fd_sc_hd__nand2_1
X_3795_ _3862_/CLK _3795_/D VGND VGND VPWR VPWR _3795_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_11_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2746_ _2746_/A _2746_/B VGND VGND VPWR VPWR _2747_/B sky130_fd_sc_hd__nor2_1
X_2677_ _3516_/B _2720_/B _2796_/B _2676_/Y VGND VGND VPWR VPWR _2678_/B sky130_fd_sc_hd__o31a_1
XTAP_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3229_ _3229_/A VGND VGND VPWR VPWR _3244_/C sky130_fd_sc_hd__inv_2
XTAP_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3580_ _3580_/A VGND VGND VPWR VPWR _3580_/Y sky130_fd_sc_hd__inv_2
X_2600_ _2600_/A VGND VGND VPWR VPWR _2600_/Y sky130_fd_sc_hd__inv_2
X_2531_ _2863_/A input5/X _3121_/A VGND VGND VPWR VPWR _2538_/A sky130_fd_sc_hd__and3_1
XFILLER_5_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2462_ _2462_/A _2816_/C _2816_/B VGND VGND VPWR VPWR _2463_/B sky130_fd_sc_hd__and3_1
XFILLER_47_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2393_ _3023_/A _3072_/A _2393_/C _2954_/C VGND VGND VPWR VPWR _2394_/B sky130_fd_sc_hd__or4_1
XFILLER_28_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3014_ _3009_/S _2292_/A _3010_/X _3013_/X VGND VGND VPWR VPWR _3015_/S sky130_fd_sc_hd__a31o_1
XFILLER_36_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3847_ _3848_/CLK _3847_/D VGND VGND VPWR VPWR _3847_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3778_ _3837_/CLK _3778_/D VGND VGND VPWR VPWR _3778_/Q sky130_fd_sc_hd__dfxtp_1
X_2729_ _2729_/A _2764_/A VGND VGND VPWR VPWR _3088_/A sky130_fd_sc_hd__nand2_1
XFILLER_59_301 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_348 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_370 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_2_0__f_i_clk clkbuf_0_i_clk/X VGND VGND VPWR VPWR _3628_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_77_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1962_ _1970_/A VGND VGND VPWR VPWR _1964_/B sky130_fd_sc_hd__inv_2
X_3701_ _3830_/CLK _3701_/D VGND VGND VPWR VPWR _3701_/Q sky130_fd_sc_hd__dfxtp_1
X_1893_ _3750_/Q VGND VGND VPWR VPWR _1894_/B sky130_fd_sc_hd__inv_2
X_3632_ _3706_/CLK _3632_/D VGND VGND VPWR VPWR _3632_/Q sky130_fd_sc_hd__dfxtp_1
X_3563_ _3565_/B _3553_/A _3411_/A VGND VGND VPWR VPWR _3563_/Y sky130_fd_sc_hd__a21oi_1
X_2514_ _3673_/Q VGND VGND VPWR VPWR _3438_/B sky130_fd_sc_hd__inv_2
X_3494_ _3882_/Q _3879_/Q _3552_/S VGND VGND VPWR VPWR _3495_/B sky130_fd_sc_hd__mux2_1
X_2445_ _2445_/A _2445_/B _2445_/C VGND VGND VPWR VPWR _2463_/A sky130_fd_sc_hd__and3_1
X_2376_ _2384_/A _3056_/A _2376_/C VGND VGND VPWR VPWR _2377_/S sky130_fd_sc_hd__and3_1
XFILLER_56_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_16 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_395 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2230_ _2229_/X _3646_/Q _2244_/S VGND VGND VPWR VPWR _3646_/D sky130_fd_sc_hd__mux2_1
XTAP_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2161_ _2721_/B VGND VGND VPWR VPWR _2863_/A sky130_fd_sc_hd__clkinv_4
X_2092_ _2092_/A _2092_/B VGND VGND VPWR VPWR _2093_/B sky130_fd_sc_hd__nand2_1
XFILLER_0_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2994_ _3002_/A _3738_/Q VGND VGND VPWR VPWR _2994_/Y sky130_fd_sc_hd__nand2_1
X_1945_ _3596_/A _3827_/Q VGND VGND VPWR VPWR _2134_/B sky130_fd_sc_hd__nand2_1
X_1876_ _2435_/A _2825_/A VGND VGND VPWR VPWR _2720_/B sky130_fd_sc_hd__nand2_4
X_3615_ _3615_/A _3615_/B VGND VGND VPWR VPWR _3615_/Y sky130_fd_sc_hd__nor2_1
X_3546_ _3559_/A _3546_/B VGND VGND VPWR VPWR _3546_/Y sky130_fd_sc_hd__nor2_1
X_3477_ _3568_/A _3477_/B VGND VGND VPWR VPWR _3477_/X sky130_fd_sc_hd__or2_1
X_2428_ _2428_/A VGND VGND VPWR VPWR _2429_/B sky130_fd_sc_hd__inv_2
X_2359_ _2359_/A _2370_/B VGND VGND VPWR VPWR _2359_/Y sky130_fd_sc_hd__nand2_1
XFILLER_29_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_292 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_68 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_104 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3400_ _3667_/Q _3606_/B _3867_/Q _3390_/Y _3399_/X VGND VGND VPWR VPWR _3867_/D
+ sky130_fd_sc_hd__o221a_1
X_3331_ _3830_/Q _2193_/X _3827_/D VGND VGND VPWR VPWR _3830_/D sky130_fd_sc_hd__mux2_1
XTAP_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3262_ _3270_/A _3852_/Q VGND VGND VPWR VPWR _3262_/X sky130_fd_sc_hd__and2_1
XTAP_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2213_ _3637_/Q _3634_/Q _3362_/S VGND VGND VPWR VPWR _2213_/X sky130_fd_sc_hd__mux2_1
XFILLER_66_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3193_ _3193_/A _3193_/B VGND VGND VPWR VPWR _3784_/D sky130_fd_sc_hd__nand2_1
X_2144_ _2185_/A _2144_/B VGND VGND VPWR VPWR _3013_/A sky130_fd_sc_hd__nor2_2
XFILLER_38_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_167 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2075_ _2102_/B _2073_/Y _2074_/Y VGND VGND VPWR VPWR _2098_/B sky130_fd_sc_hd__o21ai_1
XFILLER_14_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2977_ _2625_/A _2960_/X _2976_/Y VGND VGND VPWR VPWR _3731_/D sky130_fd_sc_hd__o21ai_1
X_1928_ _1928_/A _2185_/A _2439_/B VGND VGND VPWR VPWR _1929_/A sky130_fd_sc_hd__and3_1
X_1859_ _3750_/Q _1859_/B VGND VGND VPWR VPWR _2142_/B sky130_fd_sc_hd__nor2_4
X_3529_ _3556_/A _3685_/Q _3528_/Y _3406_/Y VGND VGND VPWR VPWR _3529_/X sky130_fd_sc_hd__a211o_1
XFILLER_1_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2900_ _3619_/A _3618_/B _3619_/B VGND VGND VPWR VPWR _2914_/B sky130_fd_sc_hd__and3_2
XFILLER_50_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3880_ _3886_/CLK _3880_/D VGND VGND VPWR VPWR _3880_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_31_376 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2831_ _3132_/B _3131_/B _3046_/B VGND VGND VPWR VPWR _2832_/A sky130_fd_sc_hd__and3_1
X_2762_ _2839_/A _2762_/B _3693_/Q VGND VGND VPWR VPWR _2762_/X sky130_fd_sc_hd__and3_1
X_2693_ _2693_/A _2895_/B VGND VGND VPWR VPWR _2693_/Y sky130_fd_sc_hd__nor2_1
XTAP_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3314_ _3314_/A _3865_/Q VGND VGND VPWR VPWR _3314_/Y sky130_fd_sc_hd__nand2_1
XTAP_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3245_ _3804_/Q _3263_/S _3244_/X VGND VGND VPWR VPWR _3804_/D sky130_fd_sc_hd__a21o_1
XTAP_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3176_ _3188_/B _3176_/B VGND VGND VPWR VPWR _3176_/Y sky130_fd_sc_hd__nor2_1
X_2127_ _2293_/A _2330_/B VGND VGND VPWR VPWR _3623_/A sky130_fd_sc_hd__nand2_4
XPHY_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2058_ _2027_/A _3732_/Q _2103_/C VGND VGND VPWR VPWR _2062_/A sky130_fd_sc_hd__nand3b_1
XFILLER_81_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_303 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput70 _3627_/Q VGND VGND VPWR VPWR o_wb_ack sky130_fd_sc_hd__clkbuf_1
Xoutput92 _3795_/Q VGND VGND VPWR VPWR o_wb_data[29] sky130_fd_sc_hd__clkbuf_1
Xoutput81 _3792_/Q VGND VGND VPWR VPWR o_wb_data[19] sky130_fd_sc_hd__clkbuf_1
X_3030_ _2854_/C _3744_/Q _2856_/A VGND VGND VPWR VPWR _3031_/B sky130_fd_sc_hd__a21oi_1
XFILLER_36_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_118 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3863_ _3901_/CLK _3863_/D VGND VGND VPWR VPWR _3863_/Q sky130_fd_sc_hd__dfxtp_1
X_2814_ _3697_/Q VGND VGND VPWR VPWR _2814_/Y sky130_fd_sc_hd__inv_2
X_3794_ _3862_/CLK _3794_/D VGND VGND VPWR VPWR _3794_/Q sky130_fd_sc_hd__dfxtp_1
X_2745_ _3692_/Q VGND VGND VPWR VPWR _2746_/A sky130_fd_sc_hd__inv_2
X_2676_ _3121_/A _2676_/B VGND VGND VPWR VPWR _2676_/Y sky130_fd_sc_hd__nand2_1
XTAP_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3228_ _3366_/S VGND VGND VPWR VPWR _3244_/A sky130_fd_sc_hd__inv_2
XTAP_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3159_ input35/X _3769_/Q _3165_/S VGND VGND VPWR VPWR _3769_/D sky130_fd_sc_hd__mux2_1
XFILLER_42_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2530_ _2529_/X _3674_/Q _2793_/A VGND VGND VPWR VPWR _3674_/D sky130_fd_sc_hd__mux2_1
XFILLER_61_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2461_ _2437_/A _2434_/A _2457_/A _2456_/Y _2460_/Y VGND VGND VPWR VPWR _2816_/B
+ sky130_fd_sc_hd__o311a_1
XFILLER_3_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2392_ _2392_/A VGND VGND VPWR VPWR _2954_/C sky130_fd_sc_hd__inv_2
XFILLER_3_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3013_ _3013_/A _3020_/A _3013_/C _3012_/X VGND VGND VPWR VPWR _3013_/X sky130_fd_sc_hd__or4b_1
XFILLER_24_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3846_ _3846_/CLK _3846_/D VGND VGND VPWR VPWR _3846_/Q sky130_fd_sc_hd__dfxtp_1
X_3777_ _3905_/CLK _3777_/D VGND VGND VPWR VPWR _3777_/Q sky130_fd_sc_hd__dfxtp_1
X_2728_ _3724_/Q _2728_/B VGND VGND VPWR VPWR _2764_/A sky130_fd_sc_hd__nor2_1
X_2659_ _3504_/B _2559_/Y _2658_/X VGND VGND VPWR VPWR _3684_/D sky130_fd_sc_hd__o21ai_1
XFILLER_59_313 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1961_ _3728_/Q _3729_/Q VGND VGND VPWR VPWR _1970_/A sky130_fd_sc_hd__nand2_1
X_3700_ _3830_/CLK _3700_/D VGND VGND VPWR VPWR _3700_/Q sky130_fd_sc_hd__dfxtp_4
X_1892_ _1892_/A VGND VGND VPWR VPWR _2164_/B sky130_fd_sc_hd__inv_2
X_3631_ _3706_/CLK _3631_/D VGND VGND VPWR VPWR _3631_/Q sky130_fd_sc_hd__dfxtp_1
X_3562_ _3568_/A _3562_/B VGND VGND VPWR VPWR _3562_/X sky130_fd_sc_hd__or2_1
X_2513_ _2512_/X _3672_/Q _2793_/A VGND VGND VPWR VPWR _3672_/D sky130_fd_sc_hd__mux2_1
X_3493_ _3556_/A _3679_/Q _3492_/Y _3406_/Y VGND VGND VPWR VPWR _3493_/X sky130_fd_sc_hd__a211o_1
X_2444_ _3067_/B _2832_/B _2949_/A _3022_/B _2443_/X VGND VGND VPWR VPWR _2445_/C
+ sky130_fd_sc_hd__o2111a_1
X_2375_ _3084_/A _3072_/A VGND VGND VPWR VPWR _2384_/A sky130_fd_sc_hd__nor2_1
XFILLER_56_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3829_ _3901_/CLK _3829_/D VGND VGND VPWR VPWR _3829_/Q sky130_fd_sc_hd__dfxtp_4
XFILLER_58_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_40_i_clk _3628_/CLK VGND VGND VPWR VPWR _3748_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_82_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2160_ _3060_/B _2160_/B _2160_/C VGND VGND VPWR VPWR _2160_/X sky130_fd_sc_hd__or3_1
XFILLER_65_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2091_ _2091_/A _2106_/A VGND VGND VPWR VPWR _2092_/B sky130_fd_sc_hd__nand2_1
XFILLER_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_382 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2993_ _2993_/A VGND VGND VPWR VPWR _2993_/Y sky130_fd_sc_hd__inv_2
XFILLER_9_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1944_ _3698_/Q _3697_/Q VGND VGND VPWR VPWR _3596_/A sky130_fd_sc_hd__nor2_1
X_3614_ _3319_/A _3612_/Y _3613_/X _3391_/Y VGND VGND VPWR VPWR _3614_/X sky130_fd_sc_hd__a31o_1
X_1875_ _1875_/A VGND VGND VPWR VPWR _2825_/A sky130_fd_sc_hd__buf_4
X_3545_ _3541_/X _3543_/X _3544_/Y _3891_/Q _3577_/A VGND VGND VPWR VPWR _3891_/D
+ sky130_fd_sc_hd__a32o_1
X_3476_ _3879_/Q _3876_/Q _3552_/S VGND VGND VPWR VPWR _3477_/B sky130_fd_sc_hd__mux2_1
X_2427_ _2825_/A _2427_/B VGND VGND VPWR VPWR _2428_/A sky130_fd_sc_hd__nor2_1
X_2358_ _3022_/A VGND VGND VPWR VPWR _2359_/A sky130_fd_sc_hd__inv_2
XFILLER_28_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_102 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2289_ _3090_/B VGND VGND VPWR VPWR _2417_/A sky130_fd_sc_hd__inv_2
XFILLER_56_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_48 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_116 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_182 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3330_ _3384_/A _3382_/B VGND VGND VPWR VPWR _3828_/D sky130_fd_sc_hd__nand2_1
XFILLER_3_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3261_ _3260_/X _3812_/Q _3263_/S VGND VGND VPWR VPWR _3812_/D sky130_fd_sc_hd__mux2_1
XTAP_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2212_ _2211_/X _3637_/Q _2244_/S VGND VGND VPWR VPWR _3637_/D sky130_fd_sc_hd__mux2_1
XTAP_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3192_ _3192_/A VGND VGND VPWR VPWR _3193_/B sky130_fd_sc_hd__inv_2
XFILLER_66_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2143_ _2391_/A _3011_/A VGND VGND VPWR VPWR _2148_/A sky130_fd_sc_hd__nand2_1
XFILLER_66_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_425 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2074_ _2105_/B _2069_/B _2102_/B _2069_/A VGND VGND VPWR VPWR _2074_/Y sky130_fd_sc_hd__o211ai_1
XFILLER_81_458 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2976_ _3002_/A _3731_/Q VGND VGND VPWR VPWR _2976_/Y sky130_fd_sc_hd__nand2_1
X_1927_ _2782_/A VGND VGND VPWR VPWR _3058_/B sky130_fd_sc_hd__clkinv_8
X_1858_ _3749_/Q VGND VGND VPWR VPWR _1859_/B sky130_fd_sc_hd__inv_2
X_3528_ _3559_/A _3528_/B VGND VGND VPWR VPWR _3528_/Y sky130_fd_sc_hd__nor2_1
X_3459_ _3568_/A _3459_/B VGND VGND VPWR VPWR _3459_/X sky130_fd_sc_hd__or2_1
XFILLER_57_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_256 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_330 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2830_ _3088_/A _3088_/B _1932_/A VGND VGND VPWR VPWR _2830_/Y sky130_fd_sc_hd__a21oi_1
X_2761_ _2761_/A VGND VGND VPWR VPWR _3199_/C sky130_fd_sc_hd__inv_2
XFILLER_31_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2692_ _3522_/B _2796_/B VGND VGND VPWR VPWR _2692_/Y sky130_fd_sc_hd__nor2_1
XFILLER_6_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_1 _2518_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3313_ _3367_/C _3379_/B _3606_/B _3579_/A VGND VGND VPWR VPWR _3313_/X sky130_fd_sc_hd__a31o_1
XTAP_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3244_ _3244_/A _3837_/Q _3244_/C VGND VGND VPWR VPWR _3244_/X sky130_fd_sc_hd__and3_1
XTAP_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_219 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3175_ _3203_/B _3076_/B _3184_/A VGND VGND VPWR VPWR _3175_/Y sky130_fd_sc_hd__a21oi_1
XFILLER_26_116 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2126_ _2187_/A _2185_/A VGND VGND VPWR VPWR _2330_/B sky130_fd_sc_hd__nand2_2
XPHY_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_17 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2057_ _2654_/A _3733_/Q VGND VGND VPWR VPWR _2103_/C sky130_fd_sc_hd__xnor2_1
XFILLER_54_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2959_ _2959_/A _3018_/B VGND VGND VPWR VPWR _3007_/A sky130_fd_sc_hd__nand2_2
XFILLER_1_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_436 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_315 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput93 _3799_/Q VGND VGND VPWR VPWR o_wb_data[2] sky130_fd_sc_hd__clkbuf_1
Xoutput82 _3798_/Q VGND VGND VPWR VPWR o_wb_data[1] sky130_fd_sc_hd__clkbuf_1
Xoutput71 _3797_/Q VGND VGND VPWR VPWR o_wb_data[0] sky130_fd_sc_hd__clkbuf_1
XFILLER_0_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_90 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3862_ _3862_/CLK _3862_/D VGND VGND VPWR VPWR _3862_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_31_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2813_ _3077_/C _2559_/Y _2812_/X VGND VGND VPWR VPWR _3696_/D sky130_fd_sc_hd__o21ai_1
X_3793_ _3862_/CLK _3793_/D VGND VGND VPWR VPWR _3793_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_8_381 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2744_ _2863_/A _3001_/A _3121_/A VGND VGND VPWR VPWR _2759_/A sky130_fd_sc_hd__and3_1
X_2675_ _3686_/Q VGND VGND VPWR VPWR _3516_/B sky130_fd_sc_hd__inv_2
XTAP_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3227_ _3226_/X _3796_/Q _3263_/S VGND VGND VPWR VPWR _3796_/D sky130_fd_sc_hd__mux2_1
XTAP_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_403 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3158_ input34/X _3768_/Q _3165_/S VGND VGND VPWR VPWR _3768_/D sky130_fd_sc_hd__mux2_1
XFILLER_54_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2109_ _2109_/A _2109_/B VGND VGND VPWR VPWR _3010_/B sky130_fd_sc_hd__nor2_1
XFILLER_36_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3089_ _3905_/Q _3904_/Q _2682_/A _2693_/A VGND VGND VPWR VPWR _3089_/X sky130_fd_sc_hd__o211a_1
XFILLER_22_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2460_ _2460_/A _2460_/B VGND VGND VPWR VPWR _2460_/Y sky130_fd_sc_hd__nand2_1
XFILLER_5_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2391_ _2391_/A _3190_/B VGND VGND VPWR VPWR _2393_/C sky130_fd_sc_hd__nand2_1
XFILLER_3_86 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3012_ _3827_/Q _3009_/S _2832_/B _2330_/B _3032_/C VGND VGND VPWR VPWR _3012_/X
+ sky130_fd_sc_hd__o2111a_1
XFILLER_24_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3845_ _3846_/CLK _3845_/D VGND VGND VPWR VPWR _3845_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_22_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3776_ _3905_/CLK _3776_/D VGND VGND VPWR VPWR _3776_/Q sky130_fd_sc_hd__dfxtp_1
X_2727_ _3777_/Q _2782_/A _2854_/B _2899_/A VGND VGND VPWR VPWR _2727_/X sky130_fd_sc_hd__a211o_1
X_2658_ _2652_/X _2653_/X _2655_/X _2657_/Y _2793_/A VGND VGND VPWR VPWR _2658_/X
+ sky130_fd_sc_hd__a41o_1
X_2589_ _2916_/A _3057_/B _3058_/B VGND VGND VPWR VPWR _2589_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_59_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1960_ _2749_/A _2044_/A VGND VGND VPWR VPWR _2083_/A sky130_fd_sc_hd__nor2_2
X_1891_ _2437_/A _2761_/A VGND VGND VPWR VPWR _1892_/A sky130_fd_sc_hd__nor2_1
X_3630_ _3706_/CLK _3630_/D VGND VGND VPWR VPWR _3630_/Q sky130_fd_sc_hd__dfxtp_1
X_3561_ _3893_/Q _3890_/Q _3607_/A VGND VGND VPWR VPWR _3562_/B sky130_fd_sc_hd__mux2_1
X_2512_ _3122_/B _2509_/X _3204_/B _2510_/X _2511_/X VGND VGND VPWR VPWR _2512_/X
+ sky130_fd_sc_hd__a2111o_1
XFILLER_52_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3492_ _3559_/A _3492_/B VGND VGND VPWR VPWR _3492_/Y sky130_fd_sc_hd__nor2_1
XFILLER_5_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2443_ _2443_/A _3032_/C VGND VGND VPWR VPWR _2443_/X sky130_fd_sc_hd__or2_1
XFILLER_68_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2374_ _3076_/B _2365_/Y _3053_/A _2373_/Y _3186_/B VGND VGND VPWR VPWR _2374_/X
+ sky130_fd_sc_hd__o221a_1
XFILLER_49_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3828_ _3865_/CLK _3828_/D VGND VGND VPWR VPWR _3828_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_20_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3759_ _3759_/CLK _3759_/D VGND VGND VPWR VPWR _3759_/Q sky130_fd_sc_hd__dfxtp_2
XFILLER_3_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_331 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2090_ _2668_/A _3734_/Q _2086_/B VGND VGND VPWR VPWR _2106_/A sky130_fd_sc_hd__o21ai_1
XFILLER_65_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_147 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2992_ _2990_/Y _2960_/X _2991_/Y VGND VGND VPWR VPWR _3737_/D sky130_fd_sc_hd__o21ai_1
XFILLER_9_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1943_ _3184_/A _2385_/A VGND VGND VPWR VPWR _1943_/Y sky130_fd_sc_hd__nor2_1
XFILLER_9_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3613_ _3903_/Q _3613_/B VGND VGND VPWR VPWR _3613_/X sky130_fd_sc_hd__or2_1
X_1874_ _3049_/B VGND VGND VPWR VPWR _3122_/B sky130_fd_sc_hd__inv_8
X_3544_ _3546_/B _3553_/A _3411_/A VGND VGND VPWR VPWR _3544_/Y sky130_fd_sc_hd__a21oi_1
X_3475_ _3556_/A _3676_/Q _3474_/Y _3406_/Y VGND VGND VPWR VPWR _3475_/X sky130_fd_sc_hd__a211o_1
X_2426_ _2455_/A _2721_/B VGND VGND VPWR VPWR _3105_/B sky130_fd_sc_hd__nor2_1
X_2357_ _2357_/A _3084_/A VGND VGND VPWR VPWR _3022_/A sky130_fd_sc_hd__nand2_2
X_2288_ _3023_/A _2953_/A _2855_/D _2288_/D VGND VGND VPWR VPWR _2305_/B sky130_fd_sc_hd__or4_1
XFILLER_56_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_147 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3260_ _3270_/A _3851_/Q VGND VGND VPWR VPWR _3260_/X sky130_fd_sc_hd__and2_1
XTAP_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2211_ _3636_/Q _3633_/Q _3362_/S VGND VGND VPWR VPWR _2211_/X sky130_fd_sc_hd__mux2_1
XTAP_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3191_ _3044_/B _3076_/B _3020_/A _2425_/A _3190_/Y VGND VGND VPWR VPWR _3192_/A
+ sky130_fd_sc_hd__a221o_1
XFILLER_66_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2142_ _2439_/C _2142_/B VGND VGND VPWR VPWR _3011_/A sky130_fd_sc_hd__nand2_8
XFILLER_26_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2073_ _2073_/A _2073_/B VGND VGND VPWR VPWR _2073_/Y sky130_fd_sc_hd__nand2_1
XFILLER_81_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_128 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2975_ _2610_/A _2960_/X _2974_/Y VGND VGND VPWR VPWR _3730_/D sky130_fd_sc_hd__o21ai_1
X_1926_ _1926_/A VGND VGND VPWR VPWR _2782_/A sky130_fd_sc_hd__buf_12
XFILLER_30_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1857_ _3024_/B VGND VGND VPWR VPWR _3618_/A sky130_fd_sc_hd__inv_2
X_3527_ _3523_/X _3525_/X _3526_/Y _3888_/Q _3577_/A VGND VGND VPWR VPWR _3888_/D
+ sky130_fd_sc_hd__a32o_1
X_3458_ _3876_/Q _3873_/Q _3552_/S VGND VGND VPWR VPWR _3459_/B sky130_fd_sc_hd__mux2_1
XFILLER_39_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3389_ _3389_/A _3389_/B VGND VGND VPWR VPWR _3579_/B sky130_fd_sc_hd__nand2_4
X_2409_ _3186_/A _2409_/B VGND VGND VPWR VPWR _2411_/A sky130_fd_sc_hd__nand2_1
XFILLER_29_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_434 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_194 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2760_ _2759_/X _3692_/Q _2803_/S VGND VGND VPWR VPWR _3692_/D sky130_fd_sc_hd__mux2_1
X_2691_ _3687_/Q VGND VGND VPWR VPWR _3522_/B sky130_fd_sc_hd__inv_2
XFILLER_61_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_2 _2686_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3312_ _3823_/Q _3306_/Y _3306_/B _3311_/X VGND VGND VPWR VPWR _3823_/D sky130_fd_sc_hd__o22a_1
XTAP_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3243_ _3803_/Q _3263_/S _3242_/X VGND VGND VPWR VPWR _3803_/D sky130_fd_sc_hd__a21o_1
XTAP_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3174_ _3174_/A VGND VGND VPWR VPWR _3206_/C sky130_fd_sc_hd__inv_2
XFILLER_66_264 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2125_ _2140_/A _2439_/B VGND VGND VPWR VPWR _2187_/A sky130_fd_sc_hd__and2_2
XFILLER_54_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2056_ _2056_/A VGND VGND VPWR VPWR _2063_/A sky130_fd_sc_hd__inv_2
XFILLER_22_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2958_ _2368_/A _2368_/B _2370_/B _2367_/A _2453_/B VGND VGND VPWR VPWR _3018_/B
+ sky130_fd_sc_hd__a311o_2
X_1909_ _3745_/Q _2810_/B VGND VGND VPWR VPWR _2729_/A sky130_fd_sc_hd__nor2_2
X_2889_ _2889_/A _3705_/Q VGND VGND VPWR VPWR _2891_/C sky130_fd_sc_hd__nand2_1
XFILLER_57_231 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_234 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_139 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_95 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput61 _3660_/Q VGND VGND VPWR VPWR o_interrupt sky130_fd_sc_hd__clkbuf_1
Xoutput94 _3796_/Q VGND VGND VPWR VPWR o_wb_data[30] sky130_fd_sc_hd__clkbuf_1
Xoutput83 _3811_/Q VGND VGND VPWR VPWR o_wb_data[20] sky130_fd_sc_hd__clkbuf_1
Xoutput72 _3807_/Q VGND VGND VPWR VPWR o_wb_data[10] sky130_fd_sc_hd__clkbuf_1
XFILLER_0_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_220 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_234 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_150 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3861_ _3861_/CLK _3861_/D VGND VGND VPWR VPWR _3861_/Q sky130_fd_sc_hd__dfxtp_1
X_3792_ _3852_/CLK _3792_/D VGND VGND VPWR VPWR _3792_/Q sky130_fd_sc_hd__dfxtp_1
X_2812_ _3131_/A _2807_/X _2809_/Y _2811_/Y _2793_/A VGND VGND VPWR VPWR _2812_/X
+ sky130_fd_sc_hd__a41o_1
X_2743_ _2742_/X _3691_/Q _2793_/A VGND VGND VPWR VPWR _3691_/D sky130_fd_sc_hd__mux2_1
XFILLER_8_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2674_ _2673_/Y _3685_/Q _2793_/A VGND VGND VPWR VPWR _3685_/D sky130_fd_sc_hd__mux2_1
XTAP_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3226_ _3860_/Q _3270_/A _3229_/A _3707_/Q VGND VGND VPWR VPWR _3226_/X sky130_fd_sc_hd__a22o_1
XTAP_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3157_ input33/X _3767_/Q _3165_/S VGND VGND VPWR VPWR _3767_/D sky130_fd_sc_hd__mux2_1
X_2108_ _2368_/A _2368_/B VGND VGND VPWR VPWR _2108_/Y sky130_fd_sc_hd__nand2_1
X_3088_ _3088_/A _3088_/B VGND VGND VPWR VPWR _3088_/Y sky130_fd_sc_hd__nand2_1
X_2039_ _2039_/A _2042_/A _2039_/C VGND VGND VPWR VPWR _2040_/B sky130_fd_sc_hd__nand3_1
XFILLER_22_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2390_ _2863_/A _2379_/Y _2389_/Y _3022_/B VGND VGND VPWR VPWR _3663_/D sky130_fd_sc_hd__o31a_1
XFILLER_68_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3011_ _3011_/A _3011_/B VGND VGND VPWR VPWR _3013_/C sky130_fd_sc_hd__nand2_1
XFILLER_17_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3844_ _3846_/CLK _3844_/D VGND VGND VPWR VPWR _3844_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_22_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3775_ _3775_/CLK _3775_/D VGND VGND VPWR VPWR _3775_/Q sky130_fd_sc_hd__dfxtp_1
X_2726_ _2726_/A VGND VGND VPWR VPWR _2899_/A sky130_fd_sc_hd__clkinv_2
X_2657_ _2657_/A _3122_/B VGND VGND VPWR VPWR _2657_/Y sky130_fd_sc_hd__nand2_1
X_2588_ _3759_/Q VGND VGND VPWR VPWR _2916_/A sky130_fd_sc_hd__inv_2
X_3209_ _3198_/X _3787_/Q _3263_/S VGND VGND VPWR VPWR _3787_/D sky130_fd_sc_hd__mux2_1
XFILLER_74_318 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_340 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1890_ _1890_/A _2797_/A VGND VGND VPWR VPWR _2761_/A sky130_fd_sc_hd__nand2_1
XFILLER_41_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3560_ _3556_/A _3690_/Q _3559_/Y _3406_/Y VGND VGND VPWR VPWR _3560_/X sky130_fd_sc_hd__a211o_1
X_2511_ _3759_/Q _2782_/A _2480_/Y _3729_/Q _2856_/B VGND VGND VPWR VPWR _2511_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_5_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3491_ _3487_/X _3489_/X _3490_/Y _3882_/Q _3577_/A VGND VGND VPWR VPWR _3882_/D
+ sky130_fd_sc_hd__a32o_1
X_2442_ _2442_/A _2817_/A _2442_/C VGND VGND VPWR VPWR _2445_/B sky130_fd_sc_hd__and3_1
XFILLER_45_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2373_ _3138_/B _2373_/B _2373_/C VGND VGND VPWR VPWR _2373_/Y sky130_fd_sc_hd__nand3_1
XFILLER_68_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3827_ _3905_/CLK _3827_/D VGND VGND VPWR VPWR _3827_/Q sky130_fd_sc_hd__dfxtp_2
X_3758_ _3759_/CLK _3758_/D VGND VGND VPWR VPWR _3758_/Q sky130_fd_sc_hd__dfxtp_2
XFILLER_3_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2709_ _2839_/A _3689_/Q VGND VGND VPWR VPWR _2709_/Y sky130_fd_sc_hd__nand2_1
X_3689_ _3725_/CLK _3689_/D VGND VGND VPWR VPWR _3689_/Q sky130_fd_sc_hd__dfxtp_2
XFILLER_58_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2991_ _3002_/A _3737_/Q VGND VGND VPWR VPWR _2991_/Y sky130_fd_sc_hd__nand2_1
X_1942_ _3131_/B _2423_/B VGND VGND VPWR VPWR _2385_/A sky130_fd_sc_hd__nand2_1
X_1873_ _2438_/B VGND VGND VPWR VPWR _3049_/B sky130_fd_sc_hd__buf_12
X_3612_ _3613_/B _3903_/Q VGND VGND VPWR VPWR _3612_/Y sky130_fd_sc_hd__nand2_1
X_3543_ _3568_/A _3543_/B VGND VGND VPWR VPWR _3543_/X sky130_fd_sc_hd__or2_1
X_3474_ _3559_/A _3474_/B VGND VGND VPWR VPWR _3474_/Y sky130_fd_sc_hd__nor2_1
X_2425_ _2425_/A _2721_/B VGND VGND VPWR VPWR _2820_/B sky130_fd_sc_hd__nor2_1
X_2356_ _3190_/B VGND VGND VPWR VPWR _3084_/A sky130_fd_sc_hd__clkinv_4
XFILLER_29_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2287_ _3206_/D _2721_/B VGND VGND VPWR VPWR _2288_/D sky130_fd_sc_hd__nand2_1
XFILLER_56_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2210_ _2209_/X _3636_/Q _2244_/S VGND VGND VPWR VPWR _3636_/D sky130_fd_sc_hd__mux2_1
XTAP_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3190_ _3190_/A _3190_/B VGND VGND VPWR VPWR _3190_/Y sky130_fd_sc_hd__nor2_1
X_2141_ _3204_/A VGND VGND VPWR VPWR _2391_/A sky130_fd_sc_hd__inv_2
X_2072_ _2105_/B VGND VGND VPWR VPWR _2073_/B sky130_fd_sc_hd__inv_2
XFILLER_46_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2974_ _3002_/A _3730_/Q VGND VGND VPWR VPWR _2974_/Y sky130_fd_sc_hd__nand2_1
X_1925_ _2109_/B _2258_/A VGND VGND VPWR VPWR _1926_/A sky130_fd_sc_hd__nor2_1
X_1856_ _1916_/A _2185_/A VGND VGND VPWR VPWR _3024_/B sky130_fd_sc_hd__nand2_2
X_3526_ _3528_/B _3553_/A _3411_/A VGND VGND VPWR VPWR _3526_/Y sky130_fd_sc_hd__a21oi_1
X_3457_ _3556_/A _3673_/Q _3456_/X _3406_/Y VGND VGND VPWR VPWR _3457_/X sky130_fd_sc_hd__a211o_1
XFILLER_69_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3388_ _3387_/X _3606_/B _3568_/A _3865_/Q _3385_/S VGND VGND VPWR VPWR _3865_/D
+ sky130_fd_sc_hd__a32o_1
X_2408_ _2408_/A _2408_/B VGND VGND VPWR VPWR _2409_/B sky130_fd_sc_hd__nor2_1
X_2339_ _2825_/A _3700_/Q VGND VGND VPWR VPWR _2340_/A sky130_fd_sc_hd__nand2_1
XFILLER_57_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_310 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_368 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2690_ _2797_/A _2798_/B VGND VGND VPWR VPWR _2690_/Y sky130_fd_sc_hd__nor2_1
XANTENNA_3 _3365_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3311_ _3555_/A _3696_/Q _3329_/A _3896_/Q _3308_/Y VGND VGND VPWR VPWR _3311_/X
+ sky130_fd_sc_hd__o32a_1
XTAP_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3242_ _3244_/A _3836_/Q _3244_/C VGND VGND VPWR VPWR _3242_/X sky130_fd_sc_hd__and3_1
XTAP_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3173_ _2165_/A _3783_/Q _3173_/S VGND VGND VPWR VPWR _3783_/D sky130_fd_sc_hd__mux2_1
XFILLER_66_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2124_ _3009_/S _2832_/B VGND VGND VPWR VPWR _3034_/B sky130_fd_sc_hd__nand2_1
XFILLER_66_276 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2055_ _2055_/A _2102_/A _2104_/A VGND VGND VPWR VPWR _2056_/A sky130_fd_sc_hd__nand3_1
XFILLER_34_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2957_ _2957_/A _2957_/B VGND VGND VPWR VPWR _2959_/A sky130_fd_sc_hd__nor2_1
X_1908_ _3099_/B VGND VGND VPWR VPWR _2810_/B sky130_fd_sc_hd__clkinv_2
X_2888_ _2888_/A _3706_/Q VGND VGND VPWR VPWR _2891_/B sky130_fd_sc_hd__nand2_1
X_1839_ _3828_/Q _3626_/Q _3746_/Q VGND VGND VPWR VPWR _1839_/X sky130_fd_sc_hd__mux2_1
X_3509_ _3505_/X _3507_/X _3508_/X _3885_/Q _3577_/A VGND VGND VPWR VPWR _3885_/D
+ sky130_fd_sc_hd__a32o_1
XTAP_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_243 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput84 _3812_/Q VGND VGND VPWR VPWR o_wb_data[21] sky130_fd_sc_hd__clkbuf_1
Xoutput73 _3808_/Q VGND VGND VPWR VPWR o_wb_data[11] sky130_fd_sc_hd__clkbuf_1
Xoutput62 _1903_/A VGND VGND VPWR VPWR o_qspi_cs_n sky130_fd_sc_hd__clkbuf_1
Xoutput95 _3862_/Q VGND VGND VPWR VPWR o_wb_data[31] sky130_fd_sc_hd__clkbuf_1
XFILLER_48_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_2_3__f_i_clk clkbuf_0_i_clk/X VGND VGND VPWR VPWR clkbuf_2_3__f_i_clk/X sky130_fd_sc_hd__clkbuf_16
XFILLER_36_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3860_ _3860_/CLK _3860_/D VGND VGND VPWR VPWR _3860_/Q sky130_fd_sc_hd__dfxtp_1
X_3791_ _3852_/CLK _3791_/D VGND VGND VPWR VPWR _3791_/Q sky130_fd_sc_hd__dfxtp_1
X_2811_ _2754_/A _2810_/X _3044_/B VGND VGND VPWR VPWR _2811_/Y sky130_fd_sc_hd__o21ai_1
X_2742_ _3084_/A _2742_/B _2742_/C _2742_/D VGND VGND VPWR VPWR _2742_/X sky130_fd_sc_hd__or4_1
XFILLER_31_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2673_ _2673_/A _2673_/B _2673_/C VGND VGND VPWR VPWR _2673_/Y sky130_fd_sc_hd__nand3_1
X_3225_ _3224_/X _3795_/Q _3263_/S VGND VGND VPWR VPWR _3795_/D sky130_fd_sc_hd__mux2_1
XTAP_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3156_ input32/X _3766_/Q _3165_/S VGND VGND VPWR VPWR _3766_/D sky130_fd_sc_hd__mux2_1
X_3087_ _3087_/A _3087_/B VGND VGND VPWR VPWR _3747_/D sky130_fd_sc_hd__nand2_1
XFILLER_27_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2107_ _2107_/A _2107_/B _2107_/C _2107_/D VGND VGND VPWR VPWR _2368_/B sky130_fd_sc_hd__and4_2
X_2038_ _2549_/B VGND VGND VPWR VPWR _2039_/C sky130_fd_sc_hd__inv_2
XFILLER_10_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_72 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3010_ _3094_/A _3010_/B _3057_/B VGND VGND VPWR VPWR _3010_/X sky130_fd_sc_hd__or3_1
XFILLER_32_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3843_ _3846_/CLK _3843_/D VGND VGND VPWR VPWR _3843_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_32_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3774_ _3774_/CLK _3774_/D VGND VGND VPWR VPWR _3774_/Q sky130_fd_sc_hd__dfxtp_1
X_2725_ _3099_/B _3690_/Q _2746_/B _2724_/Y _3044_/B VGND VGND VPWR VPWR _2725_/X
+ sky130_fd_sc_hd__o311a_1
X_2656_ _2839_/A _2762_/B _3684_/Q _3001_/A _3121_/A VGND VGND VPWR VPWR _2657_/A
+ sky130_fd_sc_hd__a32o_1
X_2587_ _3680_/Q VGND VGND VPWR VPWR _3480_/B sky130_fd_sc_hd__inv_2
X_3208_ _3366_/S VGND VGND VPWR VPWR _3263_/S sky130_fd_sc_hd__buf_8
XFILLER_67_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3139_ _2761_/A _3122_/C _3049_/B VGND VGND VPWR VPWR _3139_/X sky130_fd_sc_hd__a21o_1
XFILLER_82_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_168 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3490_ _3492_/B _3553_/A _3411_/A VGND VGND VPWR VPWR _3490_/Y sky130_fd_sc_hd__a21oi_1
X_2510_ _2608_/A _3672_/Q _2839_/A VGND VGND VPWR VPWR _2510_/X sky130_fd_sc_hd__and3_1
X_2441_ _2820_/C VGND VGND VPWR VPWR _2442_/C sky130_fd_sc_hd__inv_2
XFILLER_38_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2372_ _2368_/C _2370_/Y _2833_/B VGND VGND VPWR VPWR _2373_/C sky130_fd_sc_hd__a21oi_1
XFILLER_20_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3826_ _3901_/CLK _3826_/D VGND VGND VPWR VPWR _3826_/Q sky130_fd_sc_hd__dfxtp_4
X_3757_ _3759_/CLK _3757_/D VGND VGND VPWR VPWR _3757_/Q sky130_fd_sc_hd__dfxtp_2
XFILLER_20_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2708_ _2708_/A _3122_/B VGND VGND VPWR VPWR _2708_/Y sky130_fd_sc_hd__nand2_1
X_3688_ _3887_/CLK _3688_/D VGND VGND VPWR VPWR _3688_/Q sky130_fd_sc_hd__dfxtp_1
X_2639_ _3498_/B _2720_/B _2796_/B VGND VGND VPWR VPWR _2639_/X sky130_fd_sc_hd__or3_1
XFILLER_59_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_135 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_400 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_426 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2990_ input9/X VGND VGND VPWR VPWR _2990_/Y sky130_fd_sc_hd__inv_2
X_1941_ _2439_/C _2114_/A VGND VGND VPWR VPWR _2423_/B sky130_fd_sc_hd__nand2_2
X_1872_ _2439_/C _2439_/B VGND VGND VPWR VPWR _2438_/B sky130_fd_sc_hd__nand2_2
XFILLER_80_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3611_ _3611_/A _3611_/B _3611_/C _3611_/D VGND VGND VPWR VPWR _3611_/X sky130_fd_sc_hd__and4_1
X_3542_ _3890_/Q _3887_/Q _3607_/A VGND VGND VPWR VPWR _3543_/B sky130_fd_sc_hd__mux2_1
X_3473_ _3469_/X _3471_/X _3472_/Y _3879_/Q _3577_/A VGND VGND VPWR VPWR _3879_/D
+ sky130_fd_sc_hd__a32o_1
X_2424_ _2411_/Y _2418_/X _2423_/Y VGND VGND VPWR VPWR _2445_/A sky130_fd_sc_hd__a21oi_1
X_2355_ _3723_/Q _2355_/B VGND VGND VPWR VPWR _2357_/A sky130_fd_sc_hd__or2_1
XFILLER_69_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2286_ _2286_/A VGND VGND VPWR VPWR _3206_/D sky130_fd_sc_hd__inv_2
XFILLER_37_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_3809_ _3842_/CLK _3809_/D VGND VGND VPWR VPWR _3809_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_4_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2140_ _2140_/A _2142_/B _2187_/B VGND VGND VPWR VPWR _3204_/A sky130_fd_sc_hd__and3_2
XFILLER_66_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2071_ _2640_/B _2883_/A VGND VGND VPWR VPWR _2105_/B sky130_fd_sc_hd__nor2_1
XFILLER_75_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2973_ _2004_/B _2960_/X _2972_/Y VGND VGND VPWR VPWR _3729_/D sky130_fd_sc_hd__o21ai_1
XFILLER_61_174 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1924_ _1928_/A _2185_/A VGND VGND VPWR VPWR _2258_/A sky130_fd_sc_hd__nand2_1
X_1855_ _3751_/Q VGND VGND VPWR VPWR _2185_/A sky130_fd_sc_hd__buf_12
X_3525_ _3568_/A _3525_/B VGND VGND VPWR VPWR _3525_/X sky130_fd_sc_hd__or2_1
X_3456_ _3555_/A _3676_/Q VGND VGND VPWR VPWR _3456_/X sky130_fd_sc_hd__and2_1
X_3387_ _3382_/A _3382_/B _3386_/X _3863_/Q _3865_/Q VGND VGND VPWR VPWR _3387_/X
+ sky130_fd_sc_hd__a32o_1
X_2407_ _3011_/B _2721_/B VGND VGND VPWR VPWR _2408_/A sky130_fd_sc_hd__nand2_1
XFILLER_69_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2338_ _2338_/A _2436_/B VGND VGND VPWR VPWR _2338_/Y sky130_fd_sc_hd__nand2_1
XFILLER_29_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2269_ _3022_/B _3011_/B VGND VGND VPWR VPWR _3204_/D sky130_fd_sc_hd__nand2_1
XFILLER_57_458 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_322 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_211 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_4 _3829_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3310_ _3822_/Q _3306_/Y _3306_/B _3309_/X VGND VGND VPWR VPWR _3822_/D sky130_fd_sc_hd__o22a_1
XTAP_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3241_ _3802_/Q _3263_/S _3240_/X VGND VGND VPWR VPWR _3802_/D sky130_fd_sc_hd__a21o_1
XTAP_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3172_ input50/X _3782_/Q _3173_/S VGND VGND VPWR VPWR _3782_/D sky130_fd_sc_hd__mux2_1
XFILLER_20_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2123_ _2184_/A _2185_/A VGND VGND VPWR VPWR _2832_/B sky130_fd_sc_hd__nand2_4
XFILLER_39_436 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2054_ _2054_/A _2054_/B VGND VGND VPWR VPWR _2064_/A sky130_fd_sc_hd__nor2_1
XFILLER_34_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_450 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_369 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_2956_ _2956_/A _2956_/B _3017_/A VGND VGND VPWR VPWR _2957_/B sky130_fd_sc_hd__or3b_1
X_1907_ _3785_/Q VGND VGND VPWR VPWR _3099_/B sky130_fd_sc_hd__buf_6
X_2887_ _3706_/Q _2888_/A VGND VGND VPWR VPWR _2891_/A sky130_fd_sc_hd__or2_1
X_1838_ _1838_/A VGND VGND VPWR VPWR _3829_/D sky130_fd_sc_hd__clkinv_2
X_3508_ _3685_/Q _3606_/B _3390_/Y VGND VGND VPWR VPWR _3508_/X sky130_fd_sc_hd__o21a_1
X_3439_ _3556_/A _3670_/Q _3438_/Y _3406_/Y VGND VGND VPWR VPWR _3439_/X sky130_fd_sc_hd__a211o_1
XTAP_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_255 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_63 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput85 _3813_/Q VGND VGND VPWR VPWR o_wb_data[22] sky130_fd_sc_hd__clkbuf_1
Xoutput74 _3809_/Q VGND VGND VPWR VPWR o_wb_data[12] sky130_fd_sc_hd__clkbuf_1
Xoutput63 _1844_/Y VGND VGND VPWR VPWR o_qspi_dat[0] sky130_fd_sc_hd__clkbuf_1
Xoutput96 _3800_/Q VGND VGND VPWR VPWR o_wb_data[3] sky130_fd_sc_hd__clkbuf_1
XFILLER_0_240 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3790_ _3848_/CLK _3790_/D VGND VGND VPWR VPWR _3790_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_31_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2810_ _2839_/A _2810_/B _3696_/Q VGND VGND VPWR VPWR _2810_/X sky130_fd_sc_hd__and3_1
X_2741_ _2721_/B _2640_/Y _2740_/X VGND VGND VPWR VPWR _2742_/D sky130_fd_sc_hd__o21ai_1
XFILLER_68_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2672_ _2672_/A _3122_/B VGND VGND VPWR VPWR _2673_/C sky130_fd_sc_hd__nand2_1
X_3224_ _3859_/Q _3270_/A _3229_/A _3829_/Q VGND VGND VPWR VPWR _3224_/X sky130_fd_sc_hd__a22o_1
XTAP_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
.ends
